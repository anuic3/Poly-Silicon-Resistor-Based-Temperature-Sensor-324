v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N 180 110 240 110 { lab=#net1}
N 240 50 240 110 { lab=#net1}
N -60 50 240 50 { lab=#net1}
N -60 50 -60 110 { lab=#net1}
N -60 110 0 110 { lab=#net1}
N 320 110 340 110 { lab=#net2}
N 320 50 320 110 { lab=#net2}
N 320 50 590 50 { lab=#net2}
N 590 50 590 110 { lab=#net2}
N 520 110 590 110 { lab=#net2}
N 590 90 760 90 { lab=#net2}
N 940 110 1000 110 { lab=#net3}
N 1000 50 1000 110 { lab=#net3}
N 700 50 1000 50 { lab=#net3}
N 700 50 700 110 { lab=#net3}
N 700 110 760 110 { lab=#net3}
N 1080 110 1100 110 { lab=#net4}
N 1080 50 1080 110 { lab=#net4}
N 1080 50 1350 50 { lab=#net4}
N 1350 50 1350 110 { lab=#net4}
N 1280 110 1350 110 { lab=#net4}
N 1350 90 1520 90 { lab=#net4}
N 1700 110 1760 110 { lab=#net5}
N 1760 50 1760 110 { lab=#net5}
N 1460 50 1760 50 { lab=#net5}
N 1460 50 1460 110 { lab=#net5}
N 1460 110 1520 110 { lab=#net5}
N 1840 110 1860 110 { lab=#net6}
N 1840 50 1840 110 { lab=#net6}
N 1840 50 2110 50 { lab=#net6}
N 2110 50 2110 110 { lab=#net6}
N 2040 110 2110 110 { lab=#net6}
N 2110 90 2280 90 { lab=#net6}
N 2460 110 2520 110 { lab=#net7}
N 2520 50 2520 110 { lab=#net7}
N 2220 50 2520 50 { lab=#net7}
N 2220 50 2220 110 { lab=#net7}
N 2220 110 2280 110 { lab=#net7}
N 2600 110 2620 110 { lab=#net8}
N 2600 50 2600 110 { lab=#net8}
N 2600 50 2870 50 { lab=#net8}
N 2870 50 2870 110 { lab=#net8}
N 2800 110 2870 110 { lab=#net8}
N 2870 90 3040 90 { lab=#net8}
N 3220 110 3280 110 { lab=#net9}
N 3280 50 3280 110 { lab=#net9}
N 2980 50 3280 50 { lab=#net9}
N 2980 50 2980 110 { lab=#net9}
N 2980 110 3040 110 { lab=#net9}
N 3360 110 3380 110 { lab=#net10}
N 3360 50 3360 110 { lab=#net10}
N 3360 50 3630 50 { lab=#net10}
N 3630 50 3630 110 { lab=#net10}
N 3560 110 3630 110 { lab=#net10}
N 3630 90 3800 90 { lab=#net10}
N 3980 110 4040 110 { lab=#net11}
N 4040 50 4040 110 { lab=#net11}
N 3740 50 4040 50 { lab=#net11}
N 3740 50 3740 110 { lab=#net11}
N 3740 110 3800 110 { lab=#net11}
N 4040 90 4150 90 { lab=#net11}
N 4120 110 4140 110 { lab=#net12}
N 4120 50 4120 110 { lab=#net12}
N 4120 50 4390 50 { lab=#net12}
N 4390 50 4390 110 { lab=#net12}
N 4320 110 4390 110 { lab=#net12}
N 4390 90 4560 90 { lab=#net12}
N 4740 110 4800 110 { lab=#net13}
N 4800 50 4800 110 { lab=#net13}
N 4500 50 4800 50 { lab=#net13}
N 4500 50 4500 110 { lab=#net13}
N 4500 110 4560 110 { lab=#net13}
N 4800 90 4910 90 { lab=#net13}
N 4880 110 4900 110 { lab=#net14}
N 4880 50 4880 110 { lab=#net14}
N 4880 50 5150 50 { lab=#net14}
N 5150 50 5150 110 { lab=#net14}
N 5080 110 5150 110 { lab=#net14}
N 5150 90 5320 90 { lab=#net14}
N 5500 110 5560 110 { lab=#net15}
N 5560 50 5560 110 { lab=#net15}
N 5260 50 5560 50 { lab=#net15}
N 5260 50 5260 110 { lab=#net15}
N 5260 110 5320 110 { lab=#net15}
N 5560 90 5670 90 { lab=#net15}
N 5640 110 5660 110 { lab=#net16}
N 5640 50 5640 110 { lab=#net16}
N 5640 50 5910 50 { lab=#net16}
N 5910 50 5910 110 { lab=#net16}
N 5840 110 5910 110 { lab=#net16}
N 5910 90 6080 90 { lab=#net16}
N 6260 110 6320 110 { lab=#net17}
N 6320 50 6320 110 { lab=#net17}
N 6020 50 6320 50 { lab=#net17}
N 6020 50 6020 110 { lab=#net17}
N 6020 110 6080 110 { lab=#net17}
N 6320 90 6430 90 { lab=#net17}
N 6400 110 6420 110 { lab=#net18}
N 6400 50 6400 110 { lab=#net18}
N 6400 50 6670 50 { lab=#net18}
N 6670 50 6670 110 { lab=#net18}
N 6600 110 6670 110 { lab=#net18}
N 6670 90 6840 90 { lab=#net18}
N 7020 110 7080 110 { lab=#net19}
N 7080 50 7080 110 { lab=#net19}
N 6780 50 7080 50 { lab=#net19}
N 6780 50 6780 110 { lab=#net19}
N 6780 110 6840 110 { lab=#net19}
N 7080 90 7190 90 { lab=#net19}
N 7160 110 7180 110 { lab=#net20}
N 7160 50 7160 110 { lab=#net20}
N 7160 50 7430 50 { lab=#net20}
N 7430 50 7430 110 { lab=#net20}
N 7360 110 7430 110 { lab=#net20}
N 240 90 340 90 { lab=#net1}
N 1000 90 1100 90 { lab=#net3}
N 1760 90 1860 90 { lab=#net5}
N 2520 90 2610 90 { lab=#net7}
N 2610 90 2620 90 { lab=#net7}
N 3280 90 3380 90 { lab=#net9}
C {vsource.sym} 80 -660 0 0 {name=V1 value=1.8
}
C {gnd.sym} 80 -630 0 0 {name=l6 lab=GND}
C {vsource.sym} 110 -490 0 0 {name=V2 value="pulse(0V 1.8V clk_offset clk_risetime clk_falltime \{clk_period/2\} clk_period 0deg)"
}
C {gnd.sym} 110 -460 0 0 {name=l7 lab=GND}
C {lab_pin.sym} 110 -520 0 0 {name=l8 sig_type=std_logic lab=CLK}
C {vsource.sym} 120 -370 0 0 {name=V4 value="pwl(0.0us 1.8V, 
+ 0.090us 1.8V, 0.091us 0.0V, 
+ 0.100us 0.0V, 0.101us 1.8V)"
}
C {gnd.sym} 120 -340 0 0 {name=l9 lab=GND}
C {lab_pin.sym} 120 -400 0 0 {name=l34 sig_type=std_logic lab=RESET}
C {vdd.sym} 80 -690 0 0 {name=l10 lab=VDD}
C {code_shown.sym} 530 -440 0 0 {name=spice only_toplevel=false value="
.include ~/Desktop/counter/20bitCounter/schematic/poseEdge_Dff.spice
.lib ~/open_pdks/sky130/sky130A/libs.tech/ngspice/sky130.lib.spice tt

.param clk_period=1us clk_offset=\{clk_period/2\} clk_risetime=5ns clk_falltime=\{clk_risetime\}

.tran 10ns \{32*clk_period\}

.save CLK RESET out0 out1 out2 out3 out4
.save out5 out6 out7 out8 out9 out10 out11
.save out12 out13 out14 out15 out16 out17 out18
.save out19
"}
C {lab_pin.sym} 0 130 0 0 {name=l28 sig_type=std_logic lab=RESET}
C {lab_pin.sym} 760 130 0 0 {name=l49 sig_type=std_logic lab=RESET}
C {lab_pin.sym} 1520 130 0 0 {name=l50 sig_type=std_logic lab=RESET}
C {lab_pin.sym} 2280 130 0 0 {name=l51 sig_type=std_logic lab=RESET}
C {lab_pin.sym} 3040 130 0 0 {name=l52 sig_type=std_logic lab=RESET}
C {lab_pin.sym} 3800 130 0 0 {name=l53 sig_type=std_logic lab=RESET}
C {lab_pin.sym} 4560 130 0 0 {name=l54 sig_type=std_logic lab=RESET}
C {lab_pin.sym} 5320 130 0 0 {name=l55 sig_type=std_logic lab=RESET}
C {lab_pin.sym} 6080 130 0 0 {name=l56 sig_type=std_logic lab=RESET}
C {lab_pin.sym} 6840 130 0 0 {name=l57 sig_type=std_logic lab=RESET}
C {lab_pin.sym} 180 90 2 0 {name=l59 sig_type=std_logic lab=out0}
C {lab_pin.sym} 340 130 0 0 {name=l60 sig_type=std_logic lab=RESET}
C {lab_pin.sym} 520 90 2 0 {name=l61 sig_type=std_logic lab=out1}
C {lab_pin.sym} 940 90 2 0 {name=l62 sig_type=std_logic lab=out2}
C {lab_pin.sym} 1100 130 0 0 {name=l63 sig_type=std_logic lab=RESET}
C {lab_pin.sym} 1280 90 2 0 {name=l64 sig_type=std_logic lab=out3}
C {lab_pin.sym} 1700 90 2 0 {name=l65 sig_type=std_logic lab=out4}
C {lab_pin.sym} 1860 130 0 0 {name=l66 sig_type=std_logic lab=RESET}
C {lab_pin.sym} 2040 90 2 0 {name=l67 sig_type=std_logic lab=out5}
C {lab_pin.sym} 2460 90 2 0 {name=l68 sig_type=std_logic lab=out6}
C {lab_pin.sym} 2620 130 0 0 {name=l69 sig_type=std_logic lab=RESET}
C {lab_pin.sym} 2800 90 2 0 {name=l70 sig_type=std_logic lab=out7}
C {lab_pin.sym} 3220 90 2 0 {name=l71 sig_type=std_logic lab=out8}
C {lab_pin.sym} 3380 130 0 0 {name=l72 sig_type=std_logic lab=RESET}
C {lab_pin.sym} 3560 90 2 0 {name=l73 sig_type=std_logic lab=out9}
C {lab_pin.sym} 3560 90 2 0 {name=l74 sig_type=std_logic lab=out9}
C {lab_pin.sym} 3980 90 2 0 {name=l75 sig_type=std_logic lab=out10}
C {lab_pin.sym} 4140 130 0 0 {name=l76 sig_type=std_logic lab=RESET}
C {lab_pin.sym} 4320 90 2 0 {name=l77 sig_type=std_logic lab=out11}
C {lab_pin.sym} 4740 90 2 0 {name=l78 sig_type=std_logic lab=out12}
C {lab_pin.sym} 4900 130 0 0 {name=l79 sig_type=std_logic lab=RESET}
C {lab_pin.sym} 5080 90 2 0 {name=l80 sig_type=std_logic lab=out13}
C {lab_pin.sym} 5500 90 2 0 {name=l81 sig_type=std_logic lab=out14}
C {lab_pin.sym} 5660 130 0 0 {name=l82 sig_type=std_logic lab=RESET}
C {lab_pin.sym} 5840 90 2 0 {name=l83 sig_type=std_logic lab=out15}
C {lab_pin.sym} 6260 90 2 0 {name=l84 sig_type=std_logic lab=out16}
C {lab_pin.sym} 6420 130 0 0 {name=l85 sig_type=std_logic lab=RESET}
C {lab_pin.sym} 6600 90 2 0 {name=l86 sig_type=std_logic lab=out17}
C {lab_pin.sym} 7180 130 0 0 {name=l87 sig_type=std_logic lab=RESET}
C {lab_pin.sym} 7020 90 2 0 {name=l89 sig_type=std_logic lab=out18}
C {lab_pin.sym} 7360 90 2 0 {name=l88 sig_type=std_logic lab=out19}
C {lab_pin.sym} 0 90 0 0 {name=l58 sig_type=std_logic lab=CLK}
C {/home/cegrahul/Desktop/counter/20bitCounter/schematic/dfrbp_1.sym} 90 110 0 0 {name=x1 VGND=VGND VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {/home/cegrahul/Desktop/counter/20bitCounter/schematic/dfrbp_1.sym} 430 110 0 0 {name=x2 VGND=VGND VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {/home/cegrahul/Desktop/counter/20bitCounter/schematic/dfrbp_1.sym} 850 110 0 0 {name=x3 VGND=VGND VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {/home/cegrahul/Desktop/counter/20bitCounter/schematic/dfrbp_1.sym} 1190 110 0 0 {name=x4 VGND=VGND VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {/home/cegrahul/Desktop/counter/20bitCounter/schematic/dfrbp_1.sym} 1610 110 0 0 {name=x5 VGND=VGND VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {/home/cegrahul/Desktop/counter/20bitCounter/schematic/dfrbp_1.sym} 1950 110 0 0 {name=x6 VGND=VGND VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {/home/cegrahul/Desktop/counter/20bitCounter/schematic/dfrbp_1.sym} 2370 110 0 0 {name=x7 VGND=VGND VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {/home/cegrahul/Desktop/counter/20bitCounter/schematic/dfrbp_1.sym} 2710 110 0 0 {name=x8 VGND=VGND VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {/home/cegrahul/Desktop/counter/20bitCounter/schematic/dfrbp_1.sym} 3130 110 0 0 {name=x9 VGND=VGND VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {/home/cegrahul/Desktop/counter/20bitCounter/schematic/dfrbp_1.sym} 3470 110 0 0 {name=x10 VGND=VGND VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {/home/cegrahul/Desktop/counter/20bitCounter/schematic/dfrbp_1.sym} 3890 110 0 0 {name=x11 VGND=VGND VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {/home/cegrahul/Desktop/counter/20bitCounter/schematic/dfrbp_1.sym} 4230 110 0 0 {name=x12 VGND=VGND VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {/home/cegrahul/Desktop/counter/20bitCounter/schematic/dfrbp_1.sym} 4650 110 0 0 {name=x13 VGND=VGND VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {/home/cegrahul/Desktop/counter/20bitCounter/schematic/dfrbp_1.sym} 4990 110 0 0 {name=x14 VGND=VGND VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {/home/cegrahul/Desktop/counter/20bitCounter/schematic/dfrbp_1.sym} 5410 110 0 0 {name=x15 VGND=VGND VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {/home/cegrahul/Desktop/counter/20bitCounter/schematic/dfrbp_1.sym} 5750 110 0 0 {name=x16 VGND=VGND VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {/home/cegrahul/Desktop/counter/20bitCounter/schematic/dfrbp_1.sym} 6170 110 0 0 {name=x17 VGND=VGND VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {/home/cegrahul/Desktop/counter/20bitCounter/schematic/dfrbp_1.sym} 6510 110 0 0 {name=x18 VGND=VGND VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {/home/cegrahul/Desktop/counter/20bitCounter/schematic/dfrbp_1.sym} 6930 110 0 0 {name=x19 VGND=VGND VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {/home/cegrahul/Desktop/counter/20bitCounter/schematic/dfrbp_1.sym} 7270 110 0 0 {name=x20 VGND=VGND VPWR=VPWR prefix=sky130_fd_sc_hd__ }
