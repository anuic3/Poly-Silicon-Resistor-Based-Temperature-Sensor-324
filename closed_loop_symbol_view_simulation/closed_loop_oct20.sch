v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N 4680 1330 4770 1330 { lab=Bout}
N 4770 1160 4770 1330 { lab=Bout}
N 4770 1160 4790 1160 { lab=Bout}
N 4770 1330 4770 1450 { lab=Bout}
N 4770 1450 4800 1450 { lab=Bout}
N 5010 1450 5160 1450 { lab=#net1}
N 5000 1160 5160 1160 { lab=#net2}
N 5370 1160 5430 1160 { lab=Control_voltage}
N 5430 1160 5430 1450 { lab=Control_voltage}
N 3980 1120 4030 1120 { lab=#net3}
N 4090 1120 4090 1170 { lab=#net4}
N 4090 1230 4090 1290 { lab=#net5}
N 4090 1290 4180 1290 { lab=#net5}
N 3980 1290 4030 1290 { lab=#net6}
N 3870 1120 3920 1120 { lab=FvcoBy4_IPH}
N 4170 1120 4180 1120 { lab=#net4}
N 4090 1120 4110 1120 { lab=#net4}
N 4110 1120 4180 1120 { lab=#net4}
N 4240 1120 4250 1120 { lab=#net7}
N 4240 1120 4270 1120 { lab=#net7}
N 3860 1290 3920 1290 { lab=FvcoBy4_IPH_bar}
N 4240 1290 4260 1290 { lab=#net8}
N 4320 1290 4360 1290 { lab=vinp1}
N 4330 1120 4350 1120 { lab=vinp2}
N 5910 1390 6020 1390 { lab=clk_fdbk}
N 6020 1390 6020 1820 { lab=clk_fdbk}
N 6020 1820 6140 1820 { lab=clk_fdbk}
N 6020 1960 6140 1960 { lab=vclear}
N 5430 1310 5650 1310 { lab=Control_voltage}
N 5910 1230 6030 1230 { lab=#net9}
N 6030 1170 6030 1230 { lab=#net9}
N 6030 1170 6230 1170 { lab=#net9}
N 5910 1250 6050 1250 { lab=#net10}
N 6050 1210 6050 1250 { lab=#net10}
N 6050 1210 6230 1210 { lab=#net10}
N 5910 1270 6080 1270 { lab=#net11}
N 6080 1250 6080 1270 { lab=#net11}
N 6080 1250 6230 1250 { lab=#net11}
N 5910 1290 6230 1290 { lab=#net12}
N 6020 1490 6230 1490 { lab=clk_fdbk}
N 5910 1370 6040 1370 { lab=#net13}
N 6040 1370 6040 1450 { lab=#net13}
N 6040 1450 6230 1450 { lab=#net13}
N 5910 1350 6060 1350 { lab=#net14}
N 6060 1350 6060 1410 { lab=#net14}
N 6060 1410 6230 1410 { lab=#net14}
N 5910 1330 6080 1330 { lab=#net15}
N 6080 1330 6080 1370 { lab=#net15}
N 6080 1370 6230 1370 { lab=#net15}
N 5910 1310 6180 1310 { lab=#net16}
N 6180 1310 6180 1330 { lab=#net16}
N 6180 1330 6230 1330 { lab=#net16}
N 6520 1320 6780 1320 { lab=clk_fdbk_X9}
N 5260 1240 5320 1240 { lab=FvcoBy4_IPH}
N 4830 1240 4890 1240 { lab=FvcoBy4_IPH_bar}
N 4890 1240 4890 1370 { lab=FvcoBy4_IPH_bar}
N 5260 1240 5260 1370 { lab=FvcoBy4_IPH}
N 5150 1450 5170 1450 { lab=#net1}
N 5380 1450 5430 1450 { lab=Control_voltage}
N 6610 1980 6610 2230 { lab=FvcoBy4_QPH_bar}
N 4410 2230 6610 2230 { lab=FvcoBy4_QPH_bar}
N 4410 1380 4410 2230 { lab=FvcoBy4_QPH_bar}
N 4410 1380 4480 1380 { lab=FvcoBy4_QPH_bar}
N 6610 1920 6740 1920 { lab=FvcoBy4_QPH}
N 6740 1920 6740 2290 { lab=FvcoBy4_QPH}
N 4350 2290 6740 2290 { lab=FvcoBy4_QPH}
N 4350 1350 4350 2290 { lab=FvcoBy4_QPH}
N 4350 1350 4480 1350 { lab=FvcoBy4_QPH}
N 4350 1120 4480 1120 { lab=vinp2}
N 4360 1290 4440 1290 { lab=vinp1}
N 4440 1320 4480 1320 { lab=vinp2}
N 6610 1800 6890 1800 { lab=FvcoBy4_IPH}
N 6890 1800 6890 2480 { lab=FvcoBy4_IPH}
N 3730 2480 6890 2480 { lab=FvcoBy4_IPH}
N 3730 1120 3730 2480 { lab=FvcoBy4_IPH}
N 3730 1120 3880 1120 { lab=FvcoBy4_IPH}
N 6610 1860 6810 1860 { lab=FvcoBy4_IPH_bar}
N 6810 1860 6810 2360 { lab=FvcoBy4_IPH_bar}
N 3860 2360 6810 2360 { lab=FvcoBy4_IPH_bar}
N 3860 1290 3860 2360 { lab=FvcoBy4_IPH_bar}
N 5070 860 5480 860 { lab=#net17}
N 5070 860 5070 1080 { lab=#net17}
N 5200 860 5200 1370 { lab=#net17}
N 5080 1370 5200 1370 { lab=#net17}
N 4540 1420 4540 1520 { lab=#net18}
N 4440 1290 4480 1290 { lab=vinp1}
C {/home/dhurga/cap_80p.sym} 2640 1680 0 0 {name=Xcap}
C {/home/dhurga/cap_80p.sym} 2650 1970 0 0 {name=Xcap1}
C {/home/dhurga/sw_txgate.sym} 2580 1720 0 0 {name=Xsw1}
C {/home/dhurga/sw_txgate.sym} 2590 2010 0 0 {name=Xsw2}
C {/home/dhurga/sw_txgate.sym} 2950 1720 0 0 {name=Xsw3}
C {/home/dhurga/sw_txgate.sym} 2960 2010 0 0 {name=Xsw4}
C {/home/dhurga/ring_osc_vco.sym} 1110 2220 0 0 {name=Xvco}
C {/home/dhurga/DividerBy4.sym} -1210 2480 0 0 {name=Xdiv1}
C {/home/dhurga/Edge_combiner.sym} 790 1050 0 0 {name=Xedg1}
C {xschem_sky130/sky130_fd_pr/cap_mim_m3_1.sym} 4060 1120 3 0 {name=C7 model=cap_mim_m3_1 W=24 L=24.1 MF=4 spiceprefix=X}
C {xschem_sky130/sky130_fd_pr/res_xhigh_po_0p35.sym} 3950 1120 3 0 {name=R1
W=0.35
L=23.625
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {xschem_sky130/sky130_fd_pr/res_xhigh_po_0p35.sym} 3950 1290 3 0 {name=R2
W=0.35
L=23.625
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {xschem_sky130/sky130_fd_pr/res_xhigh_po_0p35.sym} 4210 1120 3 0 {name=R7
W=0.35
L=23.625
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {xschem_sky130/sky130_fd_pr/res_xhigh_po_0p35.sym} 4210 1290 3 0 {name=R8
W=0.35
L=23.625
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {gnd.sym} 3950 1140 0 0 {name=l45 lab=GND}
C {gnd.sym} 4210 1140 0 0 {name=l46 lab=GND}
C {xschem_sky130/sky130_fd_pr/cap_mim_m3_1.sym} 4060 1290 3 0 {name=C8 model=cap_mim_m3_1 W=24 L=24.1 MF=4 spiceprefix=X}
C {xschem_sky130/sky130_fd_pr/cap_mim_m3_1.sym} 4090 1200 0 0 {name=C9 model=cap_mim_m3_1 W=24 L=24.1 MF=2 spiceprefix=X}
C {vsource.sym} 4290 1290 3 0 {name=vin3 value="0" net_name=true

}
C {vsource.sym} 4300 1120 3 0 {name=vin4 value="0" net_name=true

}
C {lab_pin.sym} 4340 1120 1 0 {name=l47 sig_type=std_logic lab=vinp2}
C {lab_pin.sym} 4350 1290 1 0 {name=l48 sig_type=std_logic lab=vinp1}
C {gnd.sym} 3950 1310 0 0 {name=l30 lab=GND}
C {gnd.sym} 4210 1310 0 0 {name=l32 lab=GND}
C {code_shown.sym} 3870 600 0 0 {name=s1 only_toplevel=false value="
*.lib /home/dhurga/open_pdks/sky130/sky130A/libs.tech/ngspice/sky130.lib.spice ff

.temp 80

.param cl=1 m1=1
.param cw=1
.param cw1=0.55 cl1=4
.param cw2=7 cl2=8 m2=1
.param cw3=1 cl3=1 m3=1


.save Control_voltage 
.tran 0.01n 30u

.control

plot Control_voltage  

.endc"
.control
}
C {code.sym} 4770 730 0 0 {name=s2 only_toplevel=true value="

.lib /home/dhurga/open_pdks/sky130/sky130A/libs.tech/ngspice/sky130.lib.spice ff
.include /home/dhurga/poseEdge_Dff.spice
*.lib ~/open_pdks/sky130/sky130A/libs.tech/ngspice/sky130.lib.spice hh


*.include ~/open_pdks/sky130/sky130A/libs.tech/ngspice/corners/tt/nonfet.spice

 


*model
*.include ~/open_pdks/sky130/sky130A/libs.tech/ngspice/all.spice

 

*mosfet
*.include ~/open_pdks/sky130/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__pfet_01v8_lvt__tt.corner.spice
*.inclued ~/open_pdks/sky130/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__nfet_01v8_lvt__tt.corner.spice

 

*mismatch parameters
*.include ~/open_pdks/sky130/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__pfet_01v8_lvt__mismatch.corner.spice
*.include ~/open_pdks/sky130/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__nfet_01v8_lvt__mismatch.corner.spice



*mosfet
*.include ~/open_pdks/sky130/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__pfet_01v8__tt.corner.spice
*.inclued ~/open_pdks/sky130/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__nfet_01v8__tt.corner.spice



.MODEL swmod SW(VT=0.9 VH=0.01 RON=1 ROFF=1000k)
"}
C {lab_pin.sym} 6020 1960 0 0 {name=l327 sig_type=std_logic lab=vclear}
C {lab_wire.sym} 6890 1800 0 1 {name=p11 lab=FvcoBy4_IPH}
C {lab_wire.sym} 6610 1860 0 1 {name=p12 lab=FvcoBy4_IPH_bar}
C {lab_wire.sym} 6610 1920 0 1 {name=p13 lab=FvcoBy4_QPH}
C {lab_wire.sym} 6610 1980 0 1 {name=p14 lab=FvcoBy4_QPH_bar}
C {lab_pin.sym} 5270 1530 3 0 {name=l355 sig_type=std_logic lab=FvcoBy4_IPH_bar}
C {lab_pin.sym} 4840 1240 3 0 {name=l356 sig_type=std_logic lab=FvcoBy4_IPH_bar}
C {lab_pin.sym} 5310 1240 3 0 {name=l357 sig_type=std_logic lab=FvcoBy4_IPH}
C {lab_pin.sym} 5250 1080 1 0 {name=l358 sig_type=std_logic lab=FvcoBy4_IPH_bar}
C {lab_pin.sym} 4880 1080 1 0 {name=l359 sig_type=std_logic lab=FvcoBy4_IPH}
C {lab_pin.sym} 4900 1530 3 0 {name=l360 sig_type=std_logic lab=FvcoBy4_IPH}
C {vsource.sym} 6040 1990 0 0 {name=V6 value="pwl(0.000us 0.0V, 
+ 0.500us 0.0V, 0.501us 1.8V,
+ 1.500us 1.8V, 1.501us 0.0V)"
}
C {gnd.sym} 6040 2020 0 0 {name=l49 lab=GND}
C {gnd.sym} 6410 2070 0 0 {name=l50 lab=GND}
C {gnd.sym} 6390 1530 0 0 {name=l361 lab=GND}
C {gnd.sym} 5790 1420 0 0 {name=l363 lab=GND}
C {gnd.sym} 5480 920 0 0 {name=l364 lab=GND}
C {vsource.sym} 5480 890 0 0 {name=V7 value="1.8V"
}
C {lab_pin.sym} 5760 910 1 0 {name=l365 sig_type=std_logic lab=VDD}
C {gnd.sym} 5760 970 0 0 {name=l366 lab=GND}
C {vsource.sym} 5760 940 0 0 {name=V8 value="pwl(0.000us 0.0V,
+ 0.400us 0.0V, 1us 1.8V)"
}
C {lab_pin.sym} 5790 1200 1 0 {name=l367 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 6390 1130 1 0 {name=l368 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 6410 1690 1 0 {name=l369 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 6650 1320 1 0 {name=l1 sig_type=std_logic lab=clk_fdbk_X9}
C {lab_pin.sym} 6020 1680 2 0 {name=l2 sig_type=std_logic lab=clk_fdbk}
C {lab_pin.sym} 5560 1310 1 0 {name=l3 sig_type=std_logic lab=Control_voltage}
C {lab_pin.sym} 4720 1330 1 0 {name=l4 sig_type=std_logic lab=Bout}
C {/home/dhurga/CurrentBuffer_chopper.sym} 4140 130 0 0 {name=Xcbch1}
C {lab_pin.sym} 4580 1230 1 0 {name=l5 sig_type=std_logic lab=VDD}
C {gnd.sym} 4580 1420 0 0 {name=l6 lab=GND}
C {gnd.sym} 4580 1420 0 0 {name=l362 lab=GND}
C {vsource.sym} 4630 1450 0 0 {name=V27 value=0.561}
C {gnd.sym} 4630 1480 0 0 {name=l394 lab=GND}
C {vsource.sym} 4520 1450 0 0 {name=V28 value=0.8}
C {gnd.sym} 4520 1480 0 0 {name=l395 lab=GND}
C {vsource.sym} 4540 1550 0 0 {name=V29 value=1.08}
C {gnd.sym} 4540 1580 0 0 {name=l396 lab=GND}
C {lab_pin.sym} 4440 1320 0 0 {name=l7 sig_type=std_logic lab=vinp2}
