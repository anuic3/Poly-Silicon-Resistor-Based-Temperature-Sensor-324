v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
T {BUFFER fo VCO} 7020 -340 0 0 0.4 0.4 {}
T {Control voltage for VCO} 2600 -1740 0 0 0.4 0.4 {}
N 6970 -220 6990 -220 { lab=VDD}
N 6990 -250 6990 -220 { lab=VDD}
N 6970 -250 6990 -250 { lab=VDD}
N 6970 -190 6970 -90 { lab=#net1}
N 6910 -220 6930 -220 { lab=Fvco}
N 6910 -220 6910 -60 { lab=Fvco}
N 6910 -60 6930 -60 { lab=Fvco}
N 7260 -220 7280 -220 { lab=VDD}
N 7280 -250 7280 -220 { lab=VDD}
N 7260 -250 7280 -250 { lab=VDD}
N 7260 -190 7260 -90 { lab=FvcoBUF}
N 7200 -220 7220 -220 { lab=#net1}
N 7200 -220 7200 -60 { lab=#net1}
N 7200 -60 7220 -60 { lab=#net1}
N 6970 -140 7200 -140 { lab=#net1}
N 890 -430 890 -120 { lab=#net2}
N 470 1070 750 1070 { lab=#net3}
N 430 980 790 980 { lab=#net4}
N 370 1070 430 1070 { lab=#net4}
N 370 890 370 1070 { lab=#net4}
N 370 890 460 890 { lab=#net4}
N 460 890 860 890 { lab=#net4}
N 790 1070 860 1070 { lab=#net4}
N 860 1050 860 1070 { lab=#net4}
N 470 1570 750 1570 { lab=Bout_mirror}
N 430 1300 500 1300 { lab=Bout_mirror}
N 500 1300 500 1430 { lab=Bout_mirror}
N 400 1230 430 1230 { lab=#net4}
N 400 1150 400 1230 { lab=#net4}
N 790 1230 820 1230 { lab=#net4}
N 470 890 470 980 { lab=#net4}
N 820 1150 820 1230 { lab=#net4}
N 860 890 860 1070 { lab=#net4}
N 790 1290 810 1290 { lab=Bout}
N 370 1300 370 1330 { lab=#net5}
N 370 1330 430 1330 { lab=#net5}
N 730 1260 730 1290 { lab=Bout}
N 370 1260 370 1280 { lab=Bout_mirror}
N 370 1280 430 1280 { lab=Bout_mirror}
N 430 1280 430 1300 { lab=Bout_mirror}
N 730 1290 730 1330 { lab=Bout}
N 870 1290 990 1290 { lab=#net2}
N 1160 830 1300 830 { lab=#net6}
N 1340 750 1340 800 { lab=outpch2}
N 1120 750 1120 800 { lab=outpch1}
N 1120 690 1340 690 { lab=#net7}
N 1340 720 1380 720 { lab=#net8}
N 1380 600 1380 720 { lab=#net8}
N 1030 720 1120 720 { lab=#net8}
N 1030 610 1030 720 { lab=#net8}
N 1210 630 1210 690 { lab=#net7}
N 1030 580 1030 610 { lab=#net8}
N 1030 570 1030 580 { lab=#net8}
N 1030 570 1210 570 { lab=#net8}
N 1210 570 1380 570 { lab=#net8}
N 1380 570 1380 610 { lab=#net8}
N 1340 770 1370 770 { lab=outpch2}
N 1120 770 1170 770 { lab=outpch1}
N 1060 830 1120 830 { lab=GND}
N 1060 830 1060 860 { lab=GND}
N 1060 860 1120 860 { lab=GND}
N 1160 1700 1390 1700 { lab=#net9}
N 1270 1700 1270 1730 { lab=#net9}
N 1160 1570 1160 1640 { lab=outnch1}
N 1390 1570 1390 1640 { lab=outnch2}
N 1160 1450 1160 1510 { lab=#net10}
N 1390 1450 1390 1510 { lab=#net11}
N 1160 1390 1390 1390 { lab=#net12}
N 1080 1370 1200 1370 { lab=#net12}
N 1200 1370 1200 1390 { lab=#net12}
N 1200 1540 1350 1540 { lab=#net13}
N 1120 1670 1160 1670 { lab=GND}
N 1390 1670 1430 1670 { lab=GND}
N 1390 1600 1430 1600 { lab=outnch2}
N 1120 1600 1160 1600 { lab=outnch1}
N 1130 1370 1130 1540 { lab=#net12}
N 1130 1540 1160 1540 { lab=#net12}
N 1200 1370 1450 1370 { lab=#net12}
N 1450 1370 1450 1550 { lab=#net12}
N 1390 1540 1450 1540 { lab=#net12}
N 500 1430 500 1570 { lab=Bout_mirror}
N 430 1180 430 1200 { lab=vinpch1}
N 790 1180 790 1200 { lab=vinpch2}
N 820 1070 820 1150 { lab=#net4}
N 400 1070 400 1150 { lab=#net4}
N 430 1390 430 1420 { lab=vinn1}
N 430 1500 430 1540 { lab=vinnch1}
N 790 1390 790 1420 { lab=vinn2}
N 790 1520 790 1540 { lab=vinnch2}
N 430 1100 430 1130 { lab=vinp1}
N 790 1100 790 1120 { lab=vinp2}
N 790 1160 790 1180 { lab=vinpch2}
N 730 1290 800 1290 { lab=Bout}
N 430 1490 430 1510 { lab=vinnch1}
N 790 1500 790 1530 { lab=vinnch2}
N -630 940 -630 960 { lab=vinp1}
N -770 940 -630 940 { lab=vinp1}
N -770 940 -770 960 { lab=vinp1}
N -630 1020 -630 1040 { lab=vinpch1}
N -770 1040 -630 1040 { lab=vinpch1}
N -770 1020 -770 1040 { lab=vinpch1}
N -710 1040 -710 1070 { lab=vinpch1}
N -710 900 -710 940 { lab=vinp1}
N -50 930 -50 950 { lab=vinp2}
N -190 930 -50 930 { lab=vinp2}
N -190 930 -190 950 { lab=vinp2}
N -50 1010 -50 1030 { lab=vinpch2}
N -190 1030 -50 1030 { lab=vinpch2}
N -190 1010 -190 1030 { lab=vinpch2}
N -130 1030 -130 1060 { lab=vinpch2}
N -130 890 -130 930 { lab=vinp2}
N -410 870 -390 870 { lab=vinp1}
N -390 730 -390 870 { lab=vinp1}
N -410 730 -390 730 { lab=vinp1}
N -490 870 -470 870 { lab=vinpch2}
N -490 730 -490 870 { lab=vinpch2}
N -490 730 -470 730 { lab=vinpch2}
N -520 790 -490 790 { lab=vinpch2}
N -390 790 -350 790 { lab=vinp1}
N -410 1210 -390 1210 { lab=vinp2}
N -390 1070 -390 1210 { lab=vinp2}
N -410 1070 -390 1070 { lab=vinp2}
N -490 1210 -470 1210 { lab=vinpch1}
N -490 1070 -490 1210 { lab=vinpch1}
N -490 1070 -470 1070 { lab=vinpch1}
N -520 1130 -490 1130 { lab=vinpch1}
N -390 1130 -350 1130 { lab=vinp2}
N -810 840 -810 990 { lab=FvcoBy4_QPH_bar}
N -810 840 -590 840 { lab=FvcoBy4_QPH_bar}
N -590 840 -590 900 { lab=FvcoBy4_QPH_bar}
N -590 900 -590 910 { lab=FvcoBy4_QPH_bar}
N -590 910 -440 910 { lab=FvcoBy4_QPH_bar}
N -440 910 -240 910 { lab=FvcoBy4_QPH_bar}
N -240 910 -240 980 { lab=FvcoBy4_QPH_bar}
N -240 980 -230 980 { lab=FvcoBy4_QPH_bar}
N -230 980 -230 1250 { lab=FvcoBy4_QPH_bar}
N -440 1250 -230 1250 { lab=FvcoBy4_QPH_bar}
N -590 990 -590 1030 { lab=FvcoBy4_QPH}
N -590 1030 -440 1030 { lab=FvcoBy4_QPH}
N -440 1030 -310 1030 { lab=FvcoBy4_QPH}
N -310 1030 -310 1160 { lab=FvcoBy4_QPH}
N -310 1160 -10 1160 { lab=FvcoBy4_QPH}
N -10 980 -10 1160 { lab=FvcoBy4_QPH}
N -10 680 -10 980 { lab=FvcoBy4_QPH}
N -440 680 -10 680 { lab=FvcoBy4_QPH}
N -440 680 -440 690 { lab=FvcoBy4_QPH}
N -710 930 -340 930 { lab=vinp1}
N -340 790 -340 930 { lab=vinp1}
N -350 790 -340 790 { lab=vinp1}
N -710 1060 -520 1060 { lab=vinpch1}
N -520 1060 -520 1130 { lab=vinpch1}
N -360 960 -360 1130 { lab=vinp2}
N -360 960 -280 960 { lab=vinp2}
N -280 880 -280 960 { lab=vinp2}
N -280 880 -130 880 { lab=vinp2}
N -130 880 -130 890 { lab=vinp2}
N -520 600 -520 790 { lab=vinpch2}
N -520 600 70 600 { lab=vinpch2}
N 70 600 70 1050 { lab=vinpch2}
N -130 1050 70 1050 { lab=vinpch2}
N -690 1690 -690 1710 { lab=vinn1}
N -830 1690 -690 1690 { lab=vinn1}
N -830 1690 -830 1710 { lab=vinn1}
N -690 1770 -690 1790 { lab=vinnch1}
N -830 1790 -690 1790 { lab=vinnch1}
N -830 1770 -830 1790 { lab=vinnch1}
N -770 1790 -770 1820 { lab=vinnch1}
N -770 1650 -770 1690 { lab=vinn1}
N -110 1680 -110 1700 { lab=vinn2}
N -250 1680 -110 1680 { lab=vinn2}
N -250 1680 -250 1700 { lab=vinn2}
N -110 1760 -110 1780 { lab=vinnch2}
N -250 1780 -110 1780 { lab=vinnch2}
N -250 1760 -250 1780 { lab=vinnch2}
N -190 1780 -190 1810 { lab=vinnch2}
N -190 1640 -190 1680 { lab=vinn2}
N -470 1620 -450 1620 { lab=vinn1}
N -450 1480 -450 1620 { lab=vinn1}
N -470 1480 -450 1480 { lab=vinn1}
N -550 1620 -530 1620 { lab=vinnch2}
N -550 1480 -550 1620 { lab=vinnch2}
N -550 1480 -530 1480 { lab=vinnch2}
N -580 1540 -550 1540 { lab=vinnch2}
N -450 1540 -410 1540 { lab=vinn1}
N -470 1960 -450 1960 { lab=vinn2}
N -450 1820 -450 1960 { lab=vinn2}
N -470 1820 -450 1820 { lab=vinn2}
N -550 1960 -530 1960 { lab=vinnch1}
N -550 1820 -550 1960 { lab=vinnch1}
N -550 1820 -530 1820 { lab=vinnch1}
N -580 1880 -550 1880 { lab=vinnch1}
N -450 1880 -410 1880 { lab=vinn2}
N -870 1590 -870 1740 { lab=FvcoBy4_QPH_bar}
N -870 1590 -650 1590 { lab=FvcoBy4_QPH_bar}
N -650 1590 -650 1650 { lab=FvcoBy4_QPH_bar}
N -650 1650 -650 1660 { lab=FvcoBy4_QPH_bar}
N -650 1660 -500 1660 { lab=FvcoBy4_QPH_bar}
N -500 1660 -300 1660 { lab=FvcoBy4_QPH_bar}
N -300 1660 -300 1730 { lab=FvcoBy4_QPH_bar}
N -300 1730 -290 1730 { lab=FvcoBy4_QPH_bar}
N -290 1730 -290 2000 { lab=FvcoBy4_QPH_bar}
N -500 2000 -290 2000 { lab=FvcoBy4_QPH_bar}
N -650 1740 -650 1780 { lab=FvcoBy4_QPH}
N -650 1780 -500 1780 { lab=FvcoBy4_QPH}
N -500 1780 -370 1780 { lab=FvcoBy4_QPH}
N -370 1780 -370 1910 { lab=FvcoBy4_QPH}
N -370 1910 -70 1910 { lab=FvcoBy4_QPH}
N -70 1730 -70 1910 { lab=FvcoBy4_QPH}
N -70 1430 -70 1730 { lab=FvcoBy4_QPH}
N -500 1430 -70 1430 { lab=FvcoBy4_QPH}
N -500 1430 -500 1440 { lab=FvcoBy4_QPH}
N -770 1680 -400 1680 { lab=vinn1}
N -400 1540 -400 1680 { lab=vinn1}
N -410 1540 -400 1540 { lab=vinn1}
N -770 1810 -580 1810 { lab=vinnch1}
N -580 1810 -580 1880 { lab=vinnch1}
N -420 1710 -420 1880 { lab=vinn2}
N -420 1710 -340 1710 { lab=vinn2}
N -340 1630 -340 1710 { lab=vinn2}
N -340 1630 -190 1630 { lab=vinn2}
N -190 1630 -190 1640 { lab=vinn2}
N -580 1350 -580 1540 { lab=vinnch2}
N -580 1350 10 1350 { lab=vinnch2}
N 10 1350 10 1800 { lab=vinnch2}
N -190 1800 10 1800 { lab=vinnch2}
N 1840 870 1840 890 { lab=outpch1}
N 1700 870 1840 870 { lab=outpch1}
N 1700 870 1700 890 { lab=outpch1}
N 1840 950 1840 970 { lab=outp1}
N 1700 970 1840 970 { lab=outp1}
N 1700 950 1700 970 { lab=outp1}
N 1760 970 1760 1000 { lab=outp1}
N 1760 830 1760 870 { lab=outpch1}
N 2420 860 2420 880 { lab=outpch2}
N 2280 860 2420 860 { lab=outpch2}
N 2280 860 2280 880 { lab=outpch2}
N 2420 940 2420 960 { lab=outp2}
N 2280 960 2420 960 { lab=outp2}
N 2280 940 2280 960 { lab=outp2}
N 2340 960 2340 990 { lab=outp2}
N 2340 820 2340 860 { lab=outpch2}
N 2060 800 2080 800 { lab=outpch1}
N 2080 660 2080 800 { lab=outpch1}
N 2060 660 2080 660 { lab=outpch1}
N 1980 800 2000 800 { lab=outp2}
N 1980 660 1980 800 { lab=outp2}
N 1980 660 2000 660 { lab=outp2}
N 1950 720 1980 720 { lab=outp2}
N 2080 720 2120 720 { lab=outpch1}
N 2060 1140 2080 1140 { lab=outpch2}
N 2080 1000 2080 1140 { lab=outpch2}
N 2060 1000 2080 1000 { lab=outpch2}
N 1980 1140 2000 1140 { lab=outp1}
N 1980 1000 1980 1140 { lab=outp1}
N 1980 1000 2000 1000 { lab=outp1}
N 1950 1060 1980 1060 { lab=outp1}
N 2080 1060 2120 1060 { lab=outpch2}
N 1660 770 1660 920 { lab=FvcoBy4_QPH_bar}
N 1660 770 1880 770 { lab=FvcoBy4_QPH_bar}
N 1880 770 1880 830 { lab=FvcoBy4_QPH_bar}
N 1880 830 1880 840 { lab=FvcoBy4_QPH_bar}
N 1880 840 2030 840 { lab=FvcoBy4_QPH_bar}
N 2030 840 2230 840 { lab=FvcoBy4_QPH_bar}
N 2230 840 2230 910 { lab=FvcoBy4_QPH_bar}
N 2230 910 2240 910 { lab=FvcoBy4_QPH_bar}
N 2240 910 2240 1180 { lab=FvcoBy4_QPH_bar}
N 2030 1180 2240 1180 { lab=FvcoBy4_QPH_bar}
N 1880 920 1880 960 { lab=FvcoBy4_QPH}
N 1880 960 2030 960 { lab=FvcoBy4_QPH}
N 2030 960 2160 960 { lab=FvcoBy4_QPH}
N 2160 960 2160 1090 { lab=FvcoBy4_QPH}
N 2160 1090 2460 1090 { lab=FvcoBy4_QPH}
N 2460 910 2460 1090 { lab=FvcoBy4_QPH}
N 2460 610 2460 910 { lab=FvcoBy4_QPH}
N 2030 610 2460 610 { lab=FvcoBy4_QPH}
N 2030 610 2030 620 { lab=FvcoBy4_QPH}
N 1760 860 2130 860 { lab=outpch1}
N 2130 720 2130 860 { lab=outpch1}
N 2120 720 2130 720 { lab=outpch1}
N 1760 990 1950 990 { lab=outp1}
N 1950 990 1950 1060 { lab=outp1}
N 2110 890 2110 1060 { lab=outpch2}
N 2110 890 2190 890 { lab=outpch2}
N 2190 810 2190 890 { lab=outpch2}
N 2190 810 2340 810 { lab=outpch2}
N 2340 810 2340 820 { lab=outpch2}
N 1950 530 1950 720 { lab=outp2}
N 1950 530 2540 530 { lab=outp2}
N 2540 530 2540 980 { lab=outp2}
N 2340 980 2540 980 { lab=outp2}
N 1810 1670 1810 1690 { lab=outnch1}
N 1670 1670 1810 1670 { lab=outnch1}
N 1670 1670 1670 1690 { lab=outnch1}
N 1810 1750 1810 1770 { lab=outn1}
N 1670 1770 1810 1770 { lab=outn1}
N 1670 1750 1670 1770 { lab=outn1}
N 1730 1770 1730 1800 { lab=outn1}
N 1730 1630 1730 1670 { lab=outnch1}
N 2390 1660 2390 1680 { lab=outnch2}
N 2250 1660 2390 1660 { lab=outnch2}
N 2250 1660 2250 1680 { lab=outnch2}
N 2390 1740 2390 1760 { lab=outn2}
N 2250 1760 2390 1760 { lab=outn2}
N 2250 1740 2250 1760 { lab=outn2}
N 2310 1760 2310 1790 { lab=outn2}
N 2310 1620 2310 1660 { lab=outnch2}
N 2030 1600 2050 1600 { lab=outnch1}
N 2050 1460 2050 1600 { lab=outnch1}
N 2030 1460 2050 1460 { lab=outnch1}
N 1950 1600 1970 1600 { lab=outn2}
N 1950 1460 1950 1600 { lab=outn2}
N 1950 1460 1970 1460 { lab=outn2}
N 1920 1520 1950 1520 { lab=outn2}
N 2050 1520 2090 1520 { lab=outnch1}
N 2030 1940 2050 1940 { lab=outnch2}
N 2050 1800 2050 1940 { lab=outnch2}
N 2030 1800 2050 1800 { lab=outnch2}
N 1950 1940 1970 1940 { lab=outn1}
N 1950 1800 1950 1940 { lab=outn1}
N 1950 1800 1970 1800 { lab=outn1}
N 1920 1860 1950 1860 { lab=outn1}
N 2050 1860 2090 1860 { lab=outnch2}
N 1630 1570 1630 1720 { lab=FvcoBy4_QPH_bar}
N 1630 1570 1850 1570 { lab=FvcoBy4_QPH_bar}
N 1850 1570 1850 1630 { lab=FvcoBy4_QPH_bar}
N 1850 1630 1850 1640 { lab=FvcoBy4_QPH_bar}
N 1850 1640 2000 1640 { lab=FvcoBy4_QPH_bar}
N 2000 1640 2200 1640 { lab=FvcoBy4_QPH_bar}
N 2200 1640 2200 1710 { lab=FvcoBy4_QPH_bar}
N 2200 1710 2210 1710 { lab=FvcoBy4_QPH_bar}
N 2210 1710 2210 1980 { lab=FvcoBy4_QPH_bar}
N 2000 1980 2210 1980 { lab=FvcoBy4_QPH_bar}
N 1850 1720 1850 1760 { lab=FvcoBy4_QPH}
N 1850 1760 2000 1760 { lab=FvcoBy4_QPH}
N 2000 1760 2130 1760 { lab=FvcoBy4_QPH}
N 2130 1760 2130 1890 { lab=FvcoBy4_QPH}
N 2130 1890 2430 1890 { lab=FvcoBy4_QPH}
N 2430 1710 2430 1890 { lab=FvcoBy4_QPH}
N 2430 1410 2430 1710 { lab=FvcoBy4_QPH}
N 2000 1410 2430 1410 { lab=FvcoBy4_QPH}
N 2000 1410 2000 1420 { lab=FvcoBy4_QPH}
N 1730 1660 2100 1660 { lab=outnch1}
N 2100 1520 2100 1660 { lab=outnch1}
N 2090 1520 2100 1520 { lab=outnch1}
N 1730 1790 1920 1790 { lab=outn1}
N 1920 1790 1920 1860 { lab=outn1}
N 2070 1690 2070 1860 { lab=outnch2}
N 2080 1690 2160 1690 { lab=outnch2}
N 2160 1610 2160 1690 { lab=outnch2}
N 2160 1610 2310 1610 { lab=outnch2}
N 2310 1610 2310 1620 { lab=outnch2}
N 1920 1330 1920 1520 { lab=outn2}
N 1920 1330 2510 1330 { lab=outn2}
N 2510 1330 2510 1780 { lab=outn2}
N 2310 1780 2510 1780 { lab=outn2}
N 2070 1690 2120 1690 { lab=outnch2}
N -590 990 -540 990 { lab=FvcoBy4_QPH}
N -540 990 -540 1190 { lab=FvcoBy4_QPH}
N -850 1190 -540 1190 { lab=FvcoBy4_QPH}
N -860 990 -810 990 { lab=FvcoBy4_QPH_bar}
N -940 1740 -870 1740 { lab=FvcoBy4_QPH_bar}
N -650 1740 -610 1740 { lab=FvcoBy4_QPH}
N -610 1740 -610 1950 { lab=FvcoBy4_QPH}
N -930 1950 -610 1950 { lab=FvcoBy4_QPH}
N 1580 920 1660 920 { lab=FvcoBy4_QPH_bar}
N 1890 960 1890 1100 { lab=FvcoBy4_QPH}
N 1580 1100 1890 1100 { lab=FvcoBy4_QPH}
N 1560 1720 1630 1720 { lab=FvcoBy4_QPH_bar}
N 1850 1760 1850 1910 { lab=FvcoBy4_QPH}
N 1560 1910 1850 1910 { lab=FvcoBy4_QPH}
N 890 -130 890 1290 { lab=#net2}
N 4590 -650 4590 -580 { lab=#net14}
N 4590 -520 4590 -450 { lab=n1}
N 4590 -390 4590 -320 { lab=#net15}
N 4590 -420 4620 -420 { lab=GND}
N 4620 -420 4620 -230 { lab=GND}
N 4590 -230 4620 -230 { lab=GND}
N 4590 -260 4590 -230 { lab=GND}
N 4590 -260 4590 -200 { lab=GND}
N 4590 -290 4620 -290 { lab=GND}
N 4500 -550 4550 -550 { lab=Fvco}
N 4500 -550 4500 -290 { lab=Fvco}
N 4500 -290 4550 -290 { lab=Fvco}
N 4500 -420 4550 -420 { lab=Fvco}
N 4590 -480 4770 -480 { lab=n1}
N 4860 -650 4860 -580 { lab=#net14}
N 5130 -650 5130 -580 { lab=#net14}
N 5670 -650 5670 -580 { lab=#net14}
N 5940 -650 5940 -580 { lab=#net14}
N 6210 -650 6210 -580 { lab=#net14}
N 6480 -650 6480 -580 { lab=#net14}
N 6750 -650 6750 -580 { lab=#net14}
N 4590 -810 4590 -770 { lab=VDD}
N 4540 -740 4550 -740 { lab=vctrl}
N 4860 -520 4860 -450 { lab=n2}
N 4860 -390 4860 -320 { lab=#net16}
N 4860 -420 4890 -420 { lab=GND}
N 4890 -420 4890 -230 { lab=GND}
N 4860 -230 4890 -230 { lab=GND}
N 4860 -260 4860 -230 { lab=GND}
N 4860 -260 4860 -200 { lab=GND}
N 4860 -290 4890 -290 { lab=GND}
N 4770 -550 4820 -550 { lab=n1}
N 4770 -550 4770 -290 { lab=n1}
N 4770 -290 4820 -290 { lab=n1}
N 4770 -420 4820 -420 { lab=n1}
N 4860 -480 5040 -480 { lab=n2}
N 5130 -520 5130 -450 { lab=n3}
N 5130 -390 5130 -320 { lab=#net17}
N 5130 -420 5160 -420 { lab=GND}
N 5160 -420 5160 -230 { lab=GND}
N 5130 -230 5160 -230 { lab=GND}
N 5130 -260 5130 -230 { lab=GND}
N 5130 -260 5130 -200 { lab=GND}
N 5130 -290 5160 -290 { lab=GND}
N 5040 -550 5090 -550 { lab=n2}
N 5040 -550 5040 -290 { lab=n2}
N 5040 -290 5090 -290 { lab=n2}
N 5040 -420 5090 -420 { lab=n2}
N 5130 -480 5310 -480 { lab=n3}
N 5400 -520 5400 -450 { lab=n4}
N 5400 -390 5400 -320 { lab=#net18}
N 5400 -420 5430 -420 { lab=GND}
N 5430 -420 5430 -230 { lab=GND}
N 5400 -230 5430 -230 { lab=GND}
N 5400 -260 5400 -230 { lab=GND}
N 5400 -260 5400 -200 { lab=GND}
N 5400 -290 5430 -290 { lab=GND}
N 5310 -550 5360 -550 { lab=n3}
N 5310 -550 5310 -290 { lab=n3}
N 5310 -290 5360 -290 { lab=n3}
N 5310 -420 5360 -420 { lab=n3}
N 5400 -480 5580 -480 { lab=n4}
N 5670 -520 5670 -450 { lab=n5}
N 5670 -390 5670 -320 { lab=#net19}
N 5670 -420 5700 -420 { lab=GND}
N 5700 -420 5700 -230 { lab=GND}
N 5670 -230 5700 -230 { lab=GND}
N 5670 -260 5670 -230 { lab=GND}
N 5670 -260 5670 -200 { lab=GND}
N 5670 -290 5700 -290 { lab=GND}
N 5580 -550 5630 -550 { lab=n4}
N 5580 -550 5580 -290 { lab=n4}
N 5580 -290 5630 -290 { lab=n4}
N 5580 -420 5630 -420 { lab=n4}
N 5670 -480 5850 -480 { lab=n5}
N 5940 -520 5940 -450 { lab=n6}
N 5940 -390 5940 -320 { lab=#net20}
N 5940 -420 5970 -420 { lab=GND}
N 5970 -420 5970 -230 { lab=GND}
N 5940 -230 5970 -230 { lab=GND}
N 5940 -260 5940 -230 { lab=GND}
N 5940 -260 5940 -200 { lab=GND}
N 5850 -550 5900 -550 { lab=n5}
N 5850 -550 5850 -290 { lab=n5}
N 5850 -290 5900 -290 { lab=n5}
N 5850 -420 5900 -420 { lab=n5}
N 5940 -480 6120 -480 { lab=n6}
N 6210 -520 6210 -450 { lab=n7}
N 6210 -390 6210 -320 { lab=#net21}
N 6210 -420 6240 -420 { lab=GND}
N 6240 -420 6240 -230 { lab=GND}
N 6210 -230 6240 -230 { lab=GND}
N 6210 -260 6210 -230 { lab=GND}
N 6210 -260 6210 -200 { lab=GND}
N 6120 -550 6170 -550 { lab=n6}
N 6120 -550 6120 -290 { lab=n6}
N 6120 -290 6170 -290 { lab=n6}
N 6120 -420 6170 -420 { lab=n6}
N 6210 -480 6390 -480 { lab=n7}
N 6480 -520 6480 -450 { lab=n8}
N 6480 -390 6480 -320 { lab=#net22}
N 6480 -420 6510 -420 { lab=GND}
N 6510 -420 6510 -230 { lab=GND}
N 6480 -230 6510 -230 { lab=GND}
N 6480 -260 6480 -230 { lab=GND}
N 6480 -260 6480 -200 { lab=GND}
N 6390 -550 6440 -550 { lab=n7}
N 6390 -550 6390 -290 { lab=n7}
N 6390 -290 6440 -290 { lab=n7}
N 6390 -420 6440 -420 { lab=n7}
N 6480 -480 6660 -480 { lab=n8}
N 6750 -520 6750 -450 { lab=Fvco}
N 6750 -390 6750 -320 { lab=#net23}
N 6750 -420 6780 -420 { lab=GND}
N 6780 -420 6780 -230 { lab=GND}
N 6750 -230 6780 -230 { lab=GND}
N 6750 -260 6750 -230 { lab=GND}
N 6750 -260 6750 -200 { lab=GND}
N 6660 -550 6710 -550 { lab=n8}
N 6660 -550 6660 -290 { lab=n8}
N 6660 -290 6710 -290 { lab=n8}
N 6660 -420 6710 -420 { lab=n8}
N 4590 -710 4590 -650 { lab=#net14}
N 4590 -650 4860 -650 { lab=#net14}
N 4850 -650 5130 -650 { lab=#net14}
N 5130 -650 5400 -650 { lab=#net14}
N 5400 -650 5670 -650 { lab=#net14}
N 5670 -650 5940 -650 { lab=#net14}
N 5940 -650 6210 -650 { lab=#net14}
N 6210 -650 6480 -650 { lab=#net14}
N 6480 -650 6750 -650 { lab=#net14}
N 4770 -700 4770 -650 { lab=#net14}
N 4590 -870 4590 -800 { lab=VDD}
N 5400 -600 5400 -580 { lab=#net14}
N 5400 -600 5420 -600 { lab=#net14}
N 4770 -830 4770 -760 { lab=VDD}
N 4770 -770 4810 -770 { lab=VDD}
N 4810 -770 4810 -730 { lab=VDD}
N 4770 -730 4810 -730 { lab=VDD}
N 4590 -930 4650 -930 { lab=VDD}
N 4590 -740 4620 -740 { lab=VDD}
N 4620 -930 4620 -740 { lab=VDD}
N 4660 -820 4770 -820 { lab=VDD}
N 5420 -650 5420 -600 { lab=#net14}
N 4650 -930 4650 -820 { lab=VDD}
N 4650 -820 4660 -820 { lab=VDD}
N 5940 -290 5970 -290 { lab=GND}
N 6210 -290 6240 -290 { lab=GND}
N 6750 -290 6780 -290 { lab=GND}
N 6480 -290 6510 -290 { lab=GND}
N 4590 -930 4590 -870 { lab=VDD}
N 4480 -420 4500 -420 { lab=Fvco}
N 4190 -740 4540 -740 { lab=vctrl}
N 7500 -780 7500 -630 { lab=xTSPC_Dff1_Q_bar}
N 7340 -780 7500 -780 { lab=xTSPC_Dff1_Q_bar}
N 7470 -630 7500 -630 { lab=xTSPC_Dff1_Q_bar}
N 7340 -780 7340 -720 { lab=xTSPC_Dff1_Q_bar}
N 7470 -720 7670 -720 { lab=FvcoBy2}
N 7670 -630 7740 -630 { lab=FvcoBy2}
N 8100 -340 8170 -340 { lab=#net24}
N 7900 -780 7900 -630 { lab=FvcoBy4_IPH_bar}
N 7740 -780 7900 -780 { lab=FvcoBy4_IPH_bar}
N 7870 -630 7900 -630 { lab=FvcoBy4_IPH_bar}
N 7740 -780 7740 -720 { lab=FvcoBy4_IPH_bar}
N 8330 -490 8330 -340 { lab=FvcoBy4_QPH_bar}
N 8170 -490 8330 -490 { lab=FvcoBy4_QPH_bar}
N 8300 -340 8330 -340 { lab=FvcoBy4_QPH_bar}
N 8170 -490 8170 -430 { lab=FvcoBy4_QPH_bar}
N 8100 -480 8100 -340 { lab=#net24}
N 7670 -630 7670 -570 { lab=FvcoBy2}
N 7670 -720 7670 -630 { lab=FvcoBy2}
N 7130 -670 7340 -670 { lab=vclear}
N 7340 -630 7340 -500 { lab=FvcoBUF}
N 7340 -500 7340 -170 { lab=FvcoBUF}
N 7260 -170 7340 -170 { lab=FvcoBUF}
N 7900 -530 7920 -530 { lab=VDD}
N 7920 -560 7920 -530 { lab=VDD}
N 7900 -560 7920 -560 { lab=VDD}
N 7900 -500 7900 -400 { lab=#net24}
N 7840 -530 7860 -530 { lab=FvcoBy2}
N 7840 -530 7840 -370 { lab=FvcoBy2}
N 7840 -370 7860 -370 { lab=FvcoBy2}
N 7900 -480 7980 -480 { lab=#net24}
N 7980 -480 8100 -480 { lab=#net24}
N 7670 -570 7670 -480 { lab=FvcoBy2}
N 7670 -480 7840 -480 { lab=FvcoBy2}
N -610 -80 -560 -80 { lab=#net25}
N -500 -80 -500 -30 { lab=#net26}
N -500 30 -500 90 { lab=#net27}
N -500 90 -410 90 { lab=#net27}
N -610 90 -560 90 { lab=#net28}
N -720 -80 -670 -80 { lab=FvcoBy4_IPH}
N -420 -80 -410 -80 { lab=#net26}
N -500 -80 -480 -80 { lab=#net26}
N -480 -80 -410 -80 { lab=#net26}
N -350 -80 -340 -80 { lab=#net29}
N -350 -80 -320 -80 { lab=#net29}
N -730 90 -670 90 { lab=FvcoBy4_IPH_bar}
N -710 90 -710 120 { lab=FvcoBy4_IPH_bar}
N -690 -110 -690 -80 { lab=FvcoBy4_IPH}
N -350 90 -330 90 { lab=#net30}
N -270 90 -230 90 { lab=vinp1}
N -260 -80 -240 -80 { lab=vinp2}
N 890 -1080 890 -430 { lab=#net2}
N 1830 -40 2250 -40 { lab=#net31}
N 1840 -450 2270 -450 { lab=#net32}
N 2500 -450 2500 -40 { lab=vctrl}
N 1350 -450 1350 -50 { lab=#net2}
N 1350 -70 1350 -40 { lab=#net2}
N 2500 -450 2610 -450 { lab=vctrl}
N 1350 -40 1350 30 { lab=#net2}
N 890 30 1350 30 { lab=#net2}
N 1740 -410 1740 -390 { lab=#net2}
N 1600 -410 1740 -410 { lab=#net2}
N 1600 -410 1600 -390 { lab=#net2}
N 1740 -330 1740 -310 { lab=#net32}
N 1600 -310 1740 -310 { lab=#net32}
N 1600 -330 1600 -310 { lab=#net32}
N 1660 -310 1660 -280 { lab=#net32}
N 1660 -450 1660 -410 { lab=#net2}
N 1550 -360 1560 -360 { lab=FvcoBy4_IPH_bar}
N 1660 -460 1660 -450 { lab=#net2}
N 1350 -450 1660 -450 { lab=#net2}
N 1660 -280 1910 -280 { lab=#net32}
N 1910 -450 1910 -280 { lab=#net32}
N 2420 10 2420 30 { lab=#net31}
N 2280 10 2420 10 { lab=#net31}
N 2280 10 2280 30 { lab=#net31}
N 2420 90 2420 110 { lab=vctrl}
N 2280 110 2420 110 { lab=vctrl}
N 2280 90 2280 110 { lab=vctrl}
N 2340 110 2340 140 { lab=vctrl}
N 2340 -30 2340 10 { lab=#net31}
N 2230 60 2240 60 { lab=FvcoBy4_IPH_bar}
N 2340 -40 2340 -30 { lab=#net31}
N 2250 -40 2340 -40 { lab=#net31}
N 2340 140 2500 140 { lab=vctrl}
N 2500 -40 2500 140 { lab=vctrl}
N 1740 90 1740 110 { lab=#net2}
N 1600 90 1740 90 { lab=#net2}
N 1600 90 1600 110 { lab=#net2}
N 1740 170 1740 190 { lab=#net31}
N 1600 190 1740 190 { lab=#net31}
N 1600 170 1600 190 { lab=#net31}
N 1660 190 1660 220 { lab=#net31}
N 1660 50 1660 90 { lab=#net2}
N 1550 140 1560 140 { lab=FvcoBy4_IPH}
N 1660 40 1660 50 { lab=#net2}
N 1350 30 1660 30 { lab=#net2}
N 1660 30 1660 60 { lab=#net2}
N 1660 220 1820 220 { lab=#net31}
N 1820 -40 1820 220 { lab=#net31}
N 2060 -40 2090 -40 { lab=#net31}
N 2410 -390 2410 -370 { lab=#net32}
N 2270 -390 2410 -390 { lab=#net32}
N 2270 -390 2270 -370 { lab=#net32}
N 2410 -310 2410 -290 { lab=vctrl}
N 2270 -290 2410 -290 { lab=vctrl}
N 2270 -310 2270 -290 { lab=vctrl}
N 2330 -430 2330 -390 { lab=#net32}
N 2220 -340 2230 -340 { lab=FvcoBy4_IPH}
N 2330 -440 2330 -430 { lab=#net32}
N 2330 -450 2330 -420 { lab=#net32}
N 2270 -450 2340 -450 { lab=#net32}
N 2340 -290 2340 -240 { lab=vctrl}
N 2340 -240 2500 -240 { lab=vctrl}
N 2020 -620 2100 -620 { lab=#net33}
N 2020 -500 2020 -450 { lab=#net32}
N 1990 -560 1990 -540 { lab=#net33}
N 2050 -560 2050 -540 { lab=#net33}
N 2050 -620 2050 -550 { lab=#net33}
N 1990 -620 1990 -560 { lab=#net33}
N 1990 -620 2030 -620 { lab=#net33}
N 2100 -620 2210 -620 { lab=#net33}
N 2000 -210 2080 -210 { lab=#net33}
N 2000 -90 2000 -40 { lab=#net31}
N 1970 -150 1970 -130 { lab=#net33}
N 2030 -150 2030 -130 { lab=#net33}
N 2030 -210 2030 -140 { lab=#net33}
N 1970 -210 1970 -150 { lab=#net33}
N 1970 -210 2010 -210 { lab=#net33}
N 2090 -620 2090 -210 { lab=#net33}
N 2070 -210 2090 -210 { lab=#net33}
N 2190 -750 2430 -750 { lab=#net33}
N 2190 -750 2190 -630 { lab=#net33}
N 2190 -640 2190 -620 { lab=#net33}
N 5720 230 5740 230 { lab=VDD}
N 5740 200 5740 230 { lab=VDD}
N 5720 200 5740 200 { lab=VDD}
N 5720 260 5720 360 { lab=#net34}
N 5660 230 5680 230 { lab=n5}
N 5660 230 5660 390 { lab=n5}
N 5660 390 5680 390 { lab=n5}
N 6010 230 6030 230 { lab=VDD}
N 6030 200 6030 230 { lab=VDD}
N 6010 200 6030 200 { lab=VDD}
N 6010 260 6010 360 { lab=FvcoBUF5}
N 5950 230 5970 230 { lab=#net34}
N 5950 230 5950 390 { lab=#net34}
N 5950 390 5970 390 { lab=#net34}
N 5720 310 5950 310 { lab=#net34}
N 6010 280 6090 280 { lab=FvcoBUF5}
N 6410 200 6430 200 { lab=VDD}
N 6430 170 6430 200 { lab=VDD}
N 6410 170 6430 170 { lab=VDD}
N 6410 230 6410 330 { lab=#net35}
N 6350 200 6370 200 { lab=n6}
N 6350 200 6350 360 { lab=n6}
N 6350 360 6370 360 { lab=n6}
N 6700 200 6720 200 { lab=VDD}
N 6720 170 6720 200 { lab=VDD}
N 6700 170 6720 170 { lab=VDD}
N 6700 230 6700 330 { lab=FvcoBUF6}
N 6640 200 6660 200 { lab=#net35}
N 6640 200 6640 360 { lab=#net35}
N 6640 360 6660 360 { lab=#net35}
N 6410 280 6640 280 { lab=#net35}
N 6700 250 6780 250 { lab=FvcoBUF6}
N 7060 200 7080 200 { lab=VDD}
N 7080 170 7080 200 { lab=VDD}
N 7060 170 7080 170 { lab=VDD}
N 7060 230 7060 330 { lab=#net36}
N 7000 200 7020 200 { lab=n7}
N 7000 200 7000 360 { lab=n7}
N 7000 360 7020 360 { lab=n7}
N 7350 200 7370 200 { lab=VDD}
N 7370 170 7370 200 { lab=VDD}
N 7350 170 7370 170 { lab=VDD}
N 7350 230 7350 330 { lab=FvcoBUF7}
N 7290 200 7310 200 { lab=#net36}
N 7290 200 7290 360 { lab=#net36}
N 7290 360 7310 360 { lab=#net36}
N 7060 280 7290 280 { lab=#net36}
N 7350 250 7430 250 { lab=FvcoBUF7}
N 7660 190 7680 190 { lab=VDD}
N 7680 160 7680 190 { lab=VDD}
N 7660 160 7680 160 { lab=VDD}
N 7660 220 7660 320 { lab=#net37}
N 7600 190 7620 190 { lab=n8}
N 7600 190 7600 350 { lab=n8}
N 7600 350 7620 350 { lab=n8}
N 7950 190 7970 190 { lab=VDD}
N 7970 160 7970 190 { lab=VDD}
N 7950 160 7970 160 { lab=VDD}
N 7950 220 7950 320 { lab=FvcoBUF8}
N 7890 190 7910 190 { lab=#net37}
N 7890 190 7890 350 { lab=#net37}
N 7890 350 7910 350 { lab=#net37}
N 7660 270 7890 270 { lab=#net37}
N 7950 240 8030 240 { lab=FvcoBUF8}
N 8270 190 8290 190 { lab=VDD}
N 8290 160 8290 190 { lab=VDD}
N 8270 160 8290 160 { lab=VDD}
N 8270 220 8270 320 { lab=#net38}
N 8210 190 8230 190 { lab=Fvco}
N 8210 190 8210 350 { lab=Fvco}
N 8210 350 8230 350 { lab=Fvco}
N 8560 190 8580 190 { lab=VDD}
N 8580 160 8580 190 { lab=VDD}
N 8560 160 8580 160 { lab=VDD}
N 8560 220 8560 320 { lab=FvcoBUF9}
N 8500 190 8520 190 { lab=#net38}
N 8500 190 8500 350 { lab=#net38}
N 8500 350 8520 350 { lab=#net38}
N 8270 270 8500 270 { lab=#net38}
N 8560 240 8640 240 { lab=FvcoBUF9}
N 5100 250 5120 250 { lab=VDD}
N 5120 220 5120 250 { lab=VDD}
N 5100 220 5120 220 { lab=VDD}
N 5100 280 5100 380 { lab=#net39}
N 5040 250 5060 250 { lab=n4}
N 5040 250 5040 410 { lab=n4}
N 5040 410 5060 410 { lab=n4}
N 5390 250 5410 250 { lab=VDD}
N 5410 220 5410 250 { lab=VDD}
N 5390 220 5410 220 { lab=VDD}
N 5390 280 5390 380 { lab=FvcoBUF4}
N 5330 250 5350 250 { lab=#net39}
N 5330 250 5330 410 { lab=#net39}
N 5330 410 5350 410 { lab=#net39}
N 5100 330 5330 330 { lab=#net39}
N 5390 300 5470 300 { lab=FvcoBUF4}
N 4520 240 4540 240 { lab=VDD}
N 4540 210 4540 240 { lab=VDD}
N 4520 210 4540 210 { lab=VDD}
N 4520 270 4520 370 { lab=#net40}
N 4460 240 4480 240 { lab=n3}
N 4460 240 4460 400 { lab=n3}
N 4460 400 4480 400 { lab=n3}
N 4810 240 4830 240 { lab=VDD}
N 4830 210 4830 240 { lab=VDD}
N 4810 210 4830 210 { lab=VDD}
N 4810 270 4810 370 { lab=FvcoBUF3}
N 4750 240 4770 240 { lab=#net40}
N 4750 240 4750 400 { lab=#net40}
N 4750 400 4770 400 { lab=#net40}
N 4520 320 4750 320 { lab=#net40}
N 4810 290 4890 290 { lab=FvcoBUF3}
N 3910 270 3930 270 { lab=VDD}
N 3930 240 3930 270 { lab=VDD}
N 3910 240 3930 240 { lab=VDD}
N 3910 300 3910 400 { lab=#net41}
N 3850 270 3870 270 { lab=n2}
N 3850 270 3850 430 { lab=n2}
N 3850 430 3870 430 { lab=n2}
N 4200 270 4220 270 { lab=VDD}
N 4220 240 4220 270 { lab=VDD}
N 4200 240 4220 240 { lab=VDD}
N 4200 300 4200 400 { lab=FvcoBUF2}
N 4140 270 4160 270 { lab=#net41}
N 4140 270 4140 430 { lab=#net41}
N 4140 430 4160 430 { lab=#net41}
N 3910 350 4140 350 { lab=#net41}
N 4200 320 4280 320 { lab=FvcoBUF2}
N 3360 280 3380 280 { lab=VDD}
N 3380 250 3380 280 { lab=VDD}
N 3360 250 3380 250 { lab=VDD}
N 3360 310 3360 410 { lab=#net42}
N 3300 280 3320 280 { lab=n1}
N 3300 280 3300 440 { lab=n1}
N 3300 440 3320 440 { lab=n1}
N 3650 280 3670 280 { lab=VDD}
N 3670 250 3670 280 { lab=VDD}
N 3650 250 3670 250 { lab=VDD}
N 3650 310 3650 410 { lab=FvcoBUF1}
N 3590 280 3610 280 { lab=#net42}
N 3590 280 3590 440 { lab=#net42}
N 3590 440 3610 440 { lab=#net42}
N 3360 360 3590 360 { lab=#net42}
N 3650 330 3730 330 { lab=FvcoBUF1}
N 5950 1040 5950 1050 { lab=#net43}
N 5950 960 5950 980 { lab=v4}
N 5950 1110 5950 1130 { lab=GND}
N 5870 850 5870 880 { lab=VDD}
N 5870 850 5970 850 { lab=VDD}
N 5970 850 5970 880 { lab=VDD}
N 5950 820 5950 850 { lab=VDD}
N 5830 910 5830 1080 { lab=FvcoBUF5}
N 5900 910 5930 910 { lab=FvcoBUF4}
N 5900 910 5900 1010 { lab=FvcoBUF4}
N 5900 1010 5910 1010 { lab=FvcoBUF4}
N 5870 910 5880 910 { lab=VDD}
N 5880 850 5880 910 { lab=VDD}
N 5970 910 5980 910 { lab=VDD}
N 5980 850 5980 910 { lab=VDD}
N 5970 850 5980 850 { lab=VDD}
N 5950 1010 5960 1010 { lab=GND}
N 5950 1080 5960 1080 { lab=GND}
N 6270 1050 6270 1060 { lab=#net44}
N 6270 970 6270 990 { lab=v5}
N 6270 1120 6270 1140 { lab=GND}
N 6190 950 6190 970 { lab=v5}
N 6190 970 6280 970 { lab=v5}
N 6280 970 6290 970 { lab=v5}
N 6290 950 6290 970 { lab=v5}
N 6190 860 6190 890 { lab=VDD}
N 6190 860 6290 860 { lab=VDD}
N 6290 860 6290 890 { lab=VDD}
N 6270 830 6270 860 { lab=VDD}
N 6150 920 6150 1090 { lab=FvcoBUF6}
N 6220 920 6250 920 { lab=FvcoBUF5}
N 6220 920 6220 1020 { lab=FvcoBUF5}
N 6220 1020 6230 1020 { lab=FvcoBUF5}
N 6140 1020 6220 1020 { lab=FvcoBUF5}
N 6290 970 6410 970 { lab=v5}
N 6120 1020 6140 1020 { lab=FvcoBUF5}
N 6190 920 6200 920 { lab=VDD}
N 6200 860 6200 920 { lab=VDD}
N 6290 920 6300 920 { lab=VDD}
N 6300 860 6300 920 { lab=VDD}
N 6290 860 6300 860 { lab=VDD}
N 6270 1020 6280 1020 { lab=GND}
N 6280 1020 6280 1130 { lab=GND}
N 6270 1130 6280 1130 { lab=GND}
N 6270 1090 6280 1090 { lab=GND}
N 6150 1090 6170 1090 { lab=FvcoBUF6}
N 6170 1090 6230 1090 { lab=FvcoBUF6}
N 6630 1050 6630 1060 { lab=#net45}
N 6630 970 6630 990 { lab=v6}
N 6630 1120 6630 1140 { lab=GND}
N 6550 950 6550 970 { lab=v6}
N 6550 970 6640 970 { lab=v6}
N 6640 970 6650 970 { lab=v6}
N 6650 950 6650 970 { lab=v6}
N 6550 860 6550 890 { lab=VDD}
N 6550 860 6650 860 { lab=VDD}
N 6650 860 6650 890 { lab=VDD}
N 6630 830 6630 860 { lab=VDD}
N 6510 920 6510 1090 { lab=FvcoBUF7}
N 6580 920 6610 920 { lab=FvcoBUF6}
N 6580 920 6580 1020 { lab=FvcoBUF6}
N 6580 1020 6590 1020 { lab=FvcoBUF6}
N 6500 1020 6580 1020 { lab=FvcoBUF6}
N 6650 970 6770 970 { lab=v6}
N 6480 1020 6500 1020 { lab=FvcoBUF6}
N 6550 920 6560 920 { lab=VDD}
N 6560 860 6560 920 { lab=VDD}
N 6650 920 6660 920 { lab=VDD}
N 6660 860 6660 920 { lab=VDD}
N 6650 860 6660 860 { lab=VDD}
N 6630 1020 6640 1020 { lab=GND}
N 6640 1020 6640 1130 { lab=GND}
N 6630 1130 6640 1130 { lab=GND}
N 6630 1090 6640 1090 { lab=GND}
N 6510 1090 6530 1090 { lab=FvcoBUF7}
N 6530 1090 6590 1090 { lab=FvcoBUF7}
N 6990 1050 6990 1060 { lab=#net46}
N 6990 970 6990 990 { lab=v7}
N 6990 1120 6990 1140 { lab=GND}
N 6910 950 6910 970 { lab=v7}
N 6910 970 7000 970 { lab=v7}
N 7000 970 7010 970 { lab=v7}
N 7010 950 7010 970 { lab=v7}
N 6910 860 6910 890 { lab=VDD}
N 6910 860 7010 860 { lab=VDD}
N 7010 860 7010 890 { lab=VDD}
N 6990 830 6990 860 { lab=VDD}
N 6870 920 6870 1090 { lab=FvcoBUF8}
N 6940 920 6970 920 { lab=FvcoBUF7}
N 6940 920 6940 1020 { lab=FvcoBUF7}
N 6940 1020 6950 1020 { lab=FvcoBUF7}
N 6860 1020 6940 1020 { lab=FvcoBUF7}
N 7010 970 7130 970 { lab=v7}
N 6840 1020 6860 1020 { lab=FvcoBUF7}
N 6910 920 6920 920 { lab=VDD}
N 6920 860 6920 920 { lab=VDD}
N 7010 920 7020 920 { lab=VDD}
N 7020 860 7020 920 { lab=VDD}
N 7010 860 7020 860 { lab=VDD}
N 6990 1020 7000 1020 { lab=GND}
N 7000 1020 7000 1130 { lab=GND}
N 6990 1130 7000 1130 { lab=GND}
N 6990 1090 7000 1090 { lab=GND}
N 6870 1090 6890 1090 { lab=FvcoBUF8}
N 6890 1090 6950 1090 { lab=FvcoBUF8}
N 5950 1040 5950 1050 { lab=#net43}
N 5950 960 5950 980 { lab=v4}
N 5950 1110 5950 1130 { lab=GND}
N 5870 940 5870 960 { lab=v4}
N 5870 850 5870 880 { lab=VDD}
N 5870 850 5970 850 { lab=VDD}
N 5970 850 5970 880 { lab=VDD}
N 5950 820 5950 850 { lab=VDD}
N 5830 910 5830 1080 { lab=FvcoBUF5}
N 5900 910 5930 910 { lab=FvcoBUF4}
N 5900 910 5900 1010 { lab=FvcoBUF4}
N 5900 1010 5910 1010 { lab=FvcoBUF4}
N 5820 1010 5900 1010 { lab=FvcoBUF4}
N 5870 910 5880 910 { lab=VDD}
N 5880 850 5880 910 { lab=VDD}
N 5970 910 5980 910 { lab=VDD}
N 5980 850 5980 910 { lab=VDD}
N 5970 850 5980 850 { lab=VDD}
N 5950 1010 5960 1010 { lab=GND}
N 5960 1010 5960 1120 { lab=GND}
N 5950 1080 5960 1080 { lab=GND}
N 7350 1050 7350 1060 { lab=#net47}
N 7350 970 7350 990 { lab=v8}
N 7350 1120 7350 1140 { lab=GND}
N 7270 950 7270 970 { lab=v8}
N 7270 970 7360 970 { lab=v8}
N 7360 970 7370 970 { lab=v8}
N 7370 950 7370 970 { lab=v8}
N 7270 860 7270 890 { lab=VDD}
N 7270 860 7370 860 { lab=VDD}
N 7370 860 7370 890 { lab=VDD}
N 7350 830 7350 860 { lab=VDD}
N 7230 920 7230 1090 { lab=FvcoBUF9}
N 7300 920 7330 920 { lab=FvcoBUF8}
N 7300 920 7300 1020 { lab=FvcoBUF8}
N 7300 1020 7310 1020 { lab=FvcoBUF8}
N 7220 1020 7300 1020 { lab=FvcoBUF8}
N 7370 970 7490 970 { lab=v8}
N 7200 1020 7220 1020 { lab=FvcoBUF8}
N 7270 920 7280 920 { lab=VDD}
N 7280 860 7280 920 { lab=VDD}
N 7370 920 7380 920 { lab=VDD}
N 7380 860 7380 920 { lab=VDD}
N 7370 860 7380 860 { lab=VDD}
N 7350 1020 7360 1020 { lab=GND}
N 7360 1020 7360 1130 { lab=GND}
N 7350 1130 7360 1130 { lab=GND}
N 7350 1090 7360 1090 { lab=GND}
N 7230 1090 7250 1090 { lab=FvcoBUF9}
N 7250 1090 7310 1090 { lab=FvcoBUF9}
N 7690 1050 7690 1060 { lab=#net48}
N 7690 970 7690 990 { lab=v9}
N 7690 1120 7690 1140 { lab=GND}
N 7610 950 7610 970 { lab=v9}
N 7610 970 7700 970 { lab=v9}
N 7700 970 7710 970 { lab=v9}
N 7710 950 7710 970 { lab=v9}
N 7610 860 7610 890 { lab=VDD}
N 7610 860 7710 860 { lab=VDD}
N 7710 860 7710 890 { lab=VDD}
N 7690 830 7690 860 { lab=VDD}
N 7570 920 7570 1090 { lab=FvcoBUF1}
N 7640 920 7670 920 { lab=FvcoBUF9}
N 7640 920 7640 1020 { lab=FvcoBUF9}
N 7640 1020 7650 1020 { lab=FvcoBUF9}
N 7560 1020 7640 1020 { lab=FvcoBUF9}
N 7710 970 7830 970 { lab=v9}
N 7540 1020 7560 1020 { lab=FvcoBUF9}
N 7610 920 7620 920 { lab=VDD}
N 7620 860 7620 920 { lab=VDD}
N 7710 920 7720 920 { lab=VDD}
N 7720 860 7720 920 { lab=VDD}
N 7710 860 7720 860 { lab=VDD}
N 7690 1020 7700 1020 { lab=GND}
N 7700 1020 7700 1130 { lab=GND}
N 7690 1130 7700 1130 { lab=GND}
N 7690 1090 7700 1090 { lab=GND}
N 7570 1090 7590 1090 { lab=FvcoBUF1}
N 7590 1090 7650 1090 { lab=FvcoBUF1}
N 5620 1040 5620 1050 { lab=#net49}
N 5620 960 5620 980 { lab=v3}
N 5620 1110 5620 1130 { lab=GND}
N 5540 940 5540 960 { lab=v3}
N 5540 960 5630 960 { lab=v3}
N 5630 960 5640 960 { lab=v3}
N 5640 940 5640 960 { lab=v3}
N 5540 850 5540 880 { lab=VDD}
N 5540 850 5640 850 { lab=VDD}
N 5640 850 5640 880 { lab=VDD}
N 5620 820 5620 850 { lab=VDD}
N 5500 910 5500 1080 { lab=FvcoBUF4}
N 5570 910 5600 910 { lab=FvcoBUF3}
N 5570 910 5570 1010 { lab=FvcoBUF3}
N 5570 1010 5580 1010 { lab=FvcoBUF3}
N 5490 1010 5570 1010 { lab=FvcoBUF3}
N 5640 960 5760 960 { lab=v3}
N 5470 1010 5490 1010 { lab=FvcoBUF3}
N 5540 910 5550 910 { lab=VDD}
N 5550 850 5550 910 { lab=VDD}
N 5640 910 5650 910 { lab=VDD}
N 5650 850 5650 910 { lab=VDD}
N 5640 850 5650 850 { lab=VDD}
N 5620 1010 5630 1010 { lab=GND}
N 5630 1010 5630 1120 { lab=GND}
N 5620 1120 5630 1120 { lab=GND}
N 5620 1080 5630 1080 { lab=GND}
N 5500 1080 5520 1080 { lab=FvcoBUF4}
N 5520 1080 5580 1080 { lab=FvcoBUF4}
N 5280 1030 5280 1040 { lab=#net50}
N 5280 950 5280 970 { lab=v2}
N 5280 1100 5280 1120 { lab=GND}
N 5200 930 5200 950 { lab=v2}
N 5200 950 5290 950 { lab=v2}
N 5290 950 5300 950 { lab=v2}
N 5300 930 5300 950 { lab=v2}
N 5200 840 5200 870 { lab=VDD}
N 5200 840 5300 840 { lab=VDD}
N 5300 840 5300 870 { lab=VDD}
N 5280 810 5280 840 { lab=VDD}
N 5160 900 5160 1070 { lab=FvcoBUF3}
N 5230 900 5260 900 { lab=FvcoBUF2}
N 5230 900 5230 1000 { lab=FvcoBUF2}
N 5230 1000 5240 1000 { lab=FvcoBUF2}
N 5150 1000 5230 1000 { lab=FvcoBUF2}
N 5300 950 5420 950 { lab=v2}
N 5130 1000 5150 1000 { lab=FvcoBUF2}
N 5200 900 5210 900 { lab=VDD}
N 5210 840 5210 900 { lab=VDD}
N 5300 900 5310 900 { lab=VDD}
N 5310 840 5310 900 { lab=VDD}
N 5300 840 5310 840 { lab=VDD}
N 5280 1000 5290 1000 { lab=GND}
N 5290 1000 5290 1110 { lab=GND}
N 5280 1110 5290 1110 { lab=GND}
N 5280 1070 5290 1070 { lab=GND}
N 5160 1070 5180 1070 { lab=FvcoBUF3}
N 5180 1070 5240 1070 { lab=FvcoBUF3}
N 4950 1030 4950 1040 { lab=#net51}
N 4950 950 4950 970 { lab=v1}
N 4950 1100 4950 1120 { lab=GND}
N 4870 930 4870 950 { lab=v1}
N 4870 950 4960 950 { lab=v1}
N 4960 950 4970 950 { lab=v1}
N 4970 930 4970 950 { lab=v1}
N 4870 840 4870 870 { lab=VDD}
N 4870 840 4970 840 { lab=VDD}
N 4970 840 4970 870 { lab=VDD}
N 4950 810 4950 840 { lab=VDD}
N 4830 900 4830 1070 { lab=FvcoBUF2}
N 4900 900 4930 900 { lab=FvcoBUF1}
N 4900 900 4900 1000 { lab=FvcoBUF1}
N 4900 1000 4910 1000 { lab=FvcoBUF1}
N 4820 1000 4900 1000 { lab=FvcoBUF1}
N 4970 950 5090 950 { lab=v1}
N 4800 1000 4820 1000 { lab=FvcoBUF1}
N 4870 900 4880 900 { lab=VDD}
N 4880 840 4880 900 { lab=VDD}
N 4970 900 4980 900 { lab=VDD}
N 4980 840 4980 900 { lab=VDD}
N 4970 840 4980 840 { lab=VDD}
N 4950 1000 4960 1000 { lab=GND}
N 4960 1000 4960 1110 { lab=GND}
N 4950 1110 4960 1110 { lab=GND}
N 4950 1070 4960 1070 { lab=GND}
N 4830 1070 4850 1070 { lab=FvcoBUF2}
N 4850 1070 4910 1070 { lab=FvcoBUF2}
N 5870 960 6070 960 { lab=v4}
N 5970 940 5970 960 { lab=v4}
N 5830 1080 5910 1080 { lab=FvcoBUF5}
N 4710 1000 4800 1000 { lab=FvcoBUF1}
N 4710 1070 4830 1070 { lab=FvcoBUF2}
N 5080 1000 5130 1000 { lab=FvcoBUF2}
N 5080 1000 5080 1170 { lab=FvcoBUF2}
N 4710 1170 5080 1170 { lab=FvcoBUF2}
N 5120 1070 5120 1210 { lab=FvcoBUF3}
N 4710 1210 5120 1210 { lab=FvcoBUF3}
N 5120 1070 5160 1070 { lab=FvcoBUF3}
N 4710 1230 5440 1230 { lab=FvcoBUF3}
N 5440 1010 5440 1230 { lab=FvcoBUF3}
N 5440 1010 5470 1010 { lab=FvcoBUF3}
N 5480 1080 5500 1080 { lab=FvcoBUF4}
N 5480 1080 5480 1250 { lab=FvcoBUF4}
N 4710 1250 5480 1250 { lab=FvcoBUF4}
N 5730 1010 5800 1010 { lab=FvcoBUF4}
N 5730 1010 5730 1270 { lab=FvcoBUF4}
N 4710 1270 5730 1270 { lab=FvcoBUF4}
N 4710 1290 5820 1290 { lab=FvcoBUF5}
N 5820 1080 5820 1290 { lab=FvcoBUF5}
N 5820 1080 5830 1080 { lab=FvcoBUF5}
N 5800 1010 5820 1010 { lab=FvcoBUF4}
N 5950 1120 5960 1120 { lab=GND}
N 6100 1020 6120 1020 { lab=FvcoBUF5}
N 6100 1020 6100 1310 { lab=FvcoBUF5}
N 5290 1310 6100 1310 { lab=FvcoBUF5}
N 5290 1330 6140 1330 { lab=FvcoBUF6}
N 6140 1090 6140 1330 { lab=FvcoBUF6}
N 6140 1090 6150 1090 { lab=FvcoBUF6}
N 6370 1020 6480 1020 { lab=FvcoBUF6}
N 6370 1020 6370 1350 { lab=FvcoBUF6}
N 5290 1350 6370 1350 { lab=FvcoBUF6}
N 6420 1090 6510 1090 { lab=FvcoBUF7}
N 6420 1090 6420 1370 { lab=FvcoBUF7}
N 5290 1370 6420 1370 { lab=FvcoBUF7}
N 6740 1020 6840 1020 { lab=FvcoBUF7}
N 6740 1020 6740 1390 { lab=FvcoBUF7}
N 5650 1390 6740 1390 { lab=FvcoBUF7}
N 6880 1090 6880 1420 { lab=FvcoBUF8}
N 7200 1020 7200 1450 { lab=FvcoBUF8}
N 6060 1450 7200 1450 { lab=FvcoBUF8}
N 7230 1090 7230 1470 { lab=FvcoBUF9}
N 6060 1470 7230 1470 { lab=FvcoBUF9}
N 7450 1020 7540 1020 { lab=FvcoBUF9}
N 7450 1020 7450 1490 { lab=FvcoBUF9}
N 6060 1490 7450 1490 { lab=FvcoBUF9}
N 6060 1510 7600 1510 { lab=FvcoBUF1}
N 7600 1090 7600 1510 { lab=FvcoBUF1}
N 6060 1420 6880 1420 { lab=FvcoBUF8}
N 4720 1310 5290 1310 { lab=FvcoBUF5}
N 4720 1330 5280 1330 { lab=FvcoBUF6}
N 5280 1330 5290 1330 { lab=FvcoBUF6}
N 4710 1350 5290 1350 { lab=FvcoBUF6}
N 4720 1370 5290 1370 { lab=FvcoBUF7}
N 4710 1390 5650 1390 { lab=FvcoBUF7}
N 4710 1420 6060 1420 { lab=FvcoBUF8}
N 4710 1450 6060 1450 { lab=FvcoBUF8}
N 4710 1470 6060 1470 { lab=FvcoBUF9}
N 4710 1490 6060 1490 { lab=FvcoBUF9}
N 4710 1510 6060 1510 { lab=FvcoBUF1}
N 4710 1310 4720 1310 { lab=FvcoBUF5}
N 4710 1330 4720 1330 { lab=FvcoBUF6}
N 4710 1070 4710 1170 { lab=FvcoBUF2}
N 4710 1210 4710 1230 { lab=FvcoBUF3}
N 4710 1250 4710 1270 { lab=FvcoBUF4}
N 4710 1290 4710 1310 { lab=FvcoBUF5}
N 4710 1330 4710 1350 { lab=FvcoBUF6}
N 4710 1370 4710 1390 { lab=FvcoBUF7}
N 4710 1370 4720 1370 { lab=FvcoBUF7}
N 4710 1420 4710 1450 { lab=FvcoBUF8}
N 4710 1470 4710 1490 { lab=FvcoBUF9}
N 6040 1870 6060 1870 { lab=VDD}
N 6060 1840 6060 1870 { lab=VDD}
N 6040 1840 6060 1840 { lab=VDD}
N 6040 1900 6040 2000 { lab=vout}
N 5980 1870 6000 1870 { lab=v1}
N 5980 1870 5980 2030 { lab=v1}
N 5980 2030 6000 2030 { lab=v1}
N 6060 1840 6310 1840 { lab=VDD}
N 6040 1900 6310 1900 { lab=vout}
N 6200 1840 6200 1870 { lab=VDD}
N 6310 1870 6330 1870 { lab=VDD}
N 6330 1840 6330 1870 { lab=VDD}
N 6310 1840 6330 1840 { lab=VDD}
N 6040 2060 6040 2100 { lab=#net52}
N 6040 2160 6040 2180 { lab=#net53}
N 6310 1900 6380 1900 { lab=vout}
N 6180 1870 6200 1870 { lab=VDD}
N 5980 2290 6000 2290 { lab=v4}
N 6040 2320 6040 2360 { lab=#net54}
N 6040 2420 6040 2440 { lab=#net55}
N 5980 2590 6000 2590 { lab=v7}
N 6040 2620 6040 2660 { lab=#net56}
N 6040 2720 6040 2740 { lab=#net57}
N 6040 2500 6040 2560 { lab=#net58}
N 6040 2240 6040 2260 { lab=#net59}
N 6420 1870 6440 1870 { lab=VDD}
N 6440 1840 6440 1870 { lab=VDD}
N 6420 1840 6440 1840 { lab=VDD}
N 6360 1870 6380 1870 { lab=v4}
N 6440 1840 6690 1840 { lab=VDD}
N 6420 1900 6690 1900 { lab=vout}
N 6580 1840 6580 1870 { lab=VDD}
N 6690 1870 6710 1870 { lab=VDD}
N 6710 1840 6710 1870 { lab=VDD}
N 6690 1840 6710 1840 { lab=VDD}
N 6560 1870 6580 1870 { lab=VDD}
N 6800 1870 6820 1870 { lab=VDD}
N 6820 1840 6820 1870 { lab=VDD}
N 6800 1840 6820 1840 { lab=VDD}
N 6740 1870 6760 1870 { lab=v7}
N 6820 1840 7070 1840 { lab=VDD}
N 6800 1900 7070 1900 { lab=vout}
N 6960 1840 6960 1870 { lab=VDD}
N 7070 1870 7090 1870 { lab=VDD}
N 7090 1840 7090 1870 { lab=VDD}
N 7070 1840 7090 1840 { lab=VDD}
N 6940 1870 6960 1870 { lab=VDD}
N 6330 1840 6420 1840 { lab=VDD}
N 6370 1900 6430 1900 { lab=vout}
N 6690 1900 6800 1900 { lab=vout}
N 6710 1840 6800 1840 { lab=VDD}
N 2020 -620 2020 -540 { lab=#net33}
N 2000 -210 2000 -130 { lab=#net33}
N 1820 -40 1850 -40 { lab=#net31}
N 8980 1260 9040 1260 { lab=#net60}
N 9040 1200 9040 1260 { lab=#net60}
N 8740 1200 9040 1200 { lab=#net60}
N 8740 1200 8740 1260 { lab=#net60}
N 8740 1260 8800 1260 { lab=#net60}
N 9040 1240 9150 1240 { lab=#net60}
N 9130 1260 9150 1260 { lab=#net61}
N 9130 1200 9130 1260 { lab=#net61}
N 9130 1200 9400 1200 { lab=#net61}
N 9400 1200 9400 1260 { lab=#net61}
N 9330 1260 9400 1260 { lab=#net61}
N 9550 1260 9570 1260 { lab=#net62}
N 9550 1200 9550 1260 { lab=#net62}
N 9550 1200 9820 1200 { lab=#net62}
N 9820 1200 9820 1260 { lab=#net62}
N 9750 1260 9820 1260 { lab=#net62}
N 9970 1260 9990 1260 { lab=#net63}
N 9970 1200 9970 1260 { lab=#net63}
N 9970 1200 10240 1200 { lab=#net63}
N 10240 1200 10240 1260 { lab=#net63}
N 10170 1260 10240 1260 { lab=#net63}
N 10370 1260 10390 1260 { lab=#net64}
N 10370 1200 10370 1260 { lab=#net64}
N 10370 1200 10640 1200 { lab=#net64}
N 10640 1200 10640 1260 { lab=#net64}
N 10570 1260 10640 1260 { lab=#net64}
N 9400 1240 9570 1240 { lab=#net61}
N 9820 1240 9990 1240 { lab=#net62}
N 10240 1240 10390 1240 { lab=#net63}
N 10960 1260 11020 1260 { lab=#net65}
N 11020 1200 11020 1260 { lab=#net65}
N 10720 1200 11020 1200 { lab=#net65}
N 10720 1200 10720 1260 { lab=#net65}
N 10720 1260 10780 1260 { lab=#net65}
N 11020 1240 11130 1240 { lab=#net65}
N 11110 1260 11130 1260 { lab=#net66}
N 11110 1200 11110 1260 { lab=#net66}
N 11110 1200 11380 1200 { lab=#net66}
N 11380 1200 11380 1260 { lab=#net66}
N 11310 1260 11380 1260 { lab=#net66}
N 11530 1260 11550 1260 { lab=#net67}
N 11530 1200 11530 1260 { lab=#net67}
N 11530 1200 11800 1200 { lab=#net67}
N 11800 1200 11800 1260 { lab=#net67}
N 11730 1260 11800 1260 { lab=#net67}
N 11950 1260 11970 1260 { lab=#net68}
N 11950 1200 11950 1260 { lab=#net68}
N 11950 1200 12220 1200 { lab=#net68}
N 12220 1200 12220 1260 { lab=#net68}
N 12150 1260 12220 1260 { lab=#net68}
N 12350 1260 12370 1260 { lab=#net69}
N 12350 1200 12350 1260 { lab=#net69}
N 12350 1200 12620 1200 { lab=#net69}
N 12620 1200 12620 1260 { lab=#net69}
N 12550 1260 12620 1260 { lab=#net69}
N 11380 1240 11550 1240 { lab=#net66}
N 11800 1240 11970 1240 { lab=#net67}
N 12220 1240 12370 1240 { lab=#net68}
N 10640 1240 10780 1240 { lab=#net64}
N 12980 1260 13040 1260 { lab=#net70}
N 13040 1200 13040 1260 { lab=#net70}
N 12740 1200 13040 1200 { lab=#net70}
N 12740 1200 12740 1260 { lab=#net70}
N 12740 1260 12800 1260 { lab=#net70}
N 13040 1240 13150 1240 { lab=#net70}
N 13130 1260 13150 1260 { lab=#net71}
N 13130 1200 13130 1260 { lab=#net71}
N 13130 1200 13400 1200 { lab=#net71}
N 13400 1200 13400 1260 { lab=#net71}
N 13330 1260 13400 1260 { lab=#net71}
N 13550 1260 13570 1260 { lab=#net72}
N 13550 1200 13550 1260 { lab=#net72}
N 13550 1200 13820 1200 { lab=#net72}
N 13820 1200 13820 1260 { lab=#net72}
N 13750 1260 13820 1260 { lab=#net72}
N 13970 1260 13990 1260 { lab=#net73}
N 13970 1200 13970 1260 { lab=#net73}
N 13970 1200 14240 1200 { lab=#net73}
N 14240 1200 14240 1260 { lab=#net73}
N 14170 1260 14240 1260 { lab=#net73}
N 14370 1260 14390 1260 { lab=#net74}
N 14370 1200 14370 1260 { lab=#net74}
N 14370 1200 14640 1200 { lab=#net74}
N 14640 1200 14640 1260 { lab=#net74}
N 14570 1260 14640 1260 { lab=#net74}
N 13400 1240 13570 1240 { lab=#net71}
N 13820 1240 13990 1240 { lab=#net72}
N 14240 1240 14390 1240 { lab=#net73}
N 14960 1260 15020 1260 { lab=#net75}
N 15020 1200 15020 1260 { lab=#net75}
N 14720 1200 15020 1200 { lab=#net75}
N 14720 1200 14720 1260 { lab=#net75}
N 14720 1260 14780 1260 { lab=#net75}
N 15020 1240 15130 1240 { lab=#net75}
N 15110 1260 15130 1260 { lab=#net76}
N 15110 1200 15110 1260 { lab=#net76}
N 15110 1200 15380 1200 { lab=#net76}
N 15380 1200 15380 1260 { lab=#net76}
N 15310 1260 15380 1260 { lab=#net76}
N 15530 1260 15550 1260 { lab=#net77}
N 15530 1200 15530 1260 { lab=#net77}
N 15530 1200 15800 1200 { lab=#net77}
N 15800 1200 15800 1260 { lab=#net77}
N 15730 1260 15800 1260 { lab=#net77}
N 15950 1260 15970 1260 { lab=#net78}
N 15950 1200 15950 1260 { lab=#net78}
N 15950 1200 16220 1200 { lab=#net78}
N 16220 1200 16220 1260 { lab=#net78}
N 16150 1260 16220 1260 { lab=#net78}
N 16350 1260 16370 1260 { lab=#net79}
N 16350 1200 16350 1260 { lab=#net79}
N 16350 1200 16620 1200 { lab=#net79}
N 16620 1200 16620 1260 { lab=#net79}
N 16550 1260 16620 1260 { lab=#net79}
N 15380 1240 15550 1240 { lab=#net76}
N 15800 1240 15970 1240 { lab=#net77}
N 16220 1240 16370 1240 { lab=#net78}
N 14640 1240 14780 1240 { lab=#net74}
N 12620 1240 12800 1240 { lab=#net69}
N 8660 1350 8660 1390 { lab=RESET}
N 8660 1350 8690 1350 { lab=RESET}
C {code_shown.sym} -680 -870 0 0 {name=s1 only_toplevel=false value="
*.lib /home/dhurga/open_pdks/sky130/sky130A/libs.tech/ngspice/sky130.lib.spice tt

.temp -35

.param cl=1 m1=1
.param cw=1
.param cw1=0.55 cl1=4
.param cw2=7 cl2=8 m2=1
.param cw3=1 cl3=1 m3=1


.save out0 out1 out2 out3 out4 out5 out6 out7 out8 out9 out10 out11 out12 out13
.tran 0.1n 1m 990u

"

}
C {code.sym} -250 -1120 0 0 {name=s2 only_toplevel=true value="

.lib /home/dhurga/open_pdks/sky130/sky130A/libs.tech/ngspice/sky130.lib.spice tt
.include /home/dhurga/poseEdge_Dff.spice
*.lib ~/open_pdks/sky130/sky130A/libs.tech/ngspice/sky130.lib.spice hh


*.include ~/open_pdks/sky130/sky130A/libs.tech/ngspice/corners/tt/nonfet.spice

 


*model
*.include ~/open_pdks/sky130/sky130A/libs.tech/ngspice/all.spice

 

*mosfet
*.include ~/open_pdks/sky130/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__pfet_01v8_lvt__tt.corner.spice
*.inclued ~/open_pdks/sky130/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__nfet_01v8_lvt__tt.corner.spice

 

*mismatch parameters
*.include ~/open_pdks/sky130/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__pfet_01v8_lvt__mismatch.corner.spice
*.include ~/open_pdks/sky130/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__nfet_01v8_lvt__mismatch.corner.spice



*mosfet
*.include ~/open_pdks/sky130/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__pfet_01v8__tt.corner.spice
*.inclued ~/open_pdks/sky130/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__nfet_01v8__tt.corner.spice



.MODEL swmod SW(VT=0.9 VH=0.01 RON=1 ROFF=1000k)
"}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 6950 -220 0 0 {name=M100
L=0.15
W=1.68
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet_01v8.sym} 6950 -60 0 0 {name=M101
L=0.15
W=0.36
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 6970 -60 2 0 {name=l124 sig_type=std_logic lab=GND}
C {gnd.sym} 6970 -30 0 0 {name=l128 lab=GND}
C {lab_pin.sym} 6970 -250 1 0 {name=l129 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 6910 -110 0 0 {name=l130 sig_type=std_logic lab=Fvco}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 7240 -220 0 0 {name=M102
L=0.15
W=1.68
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet_01v8.sym} 7240 -60 0 0 {name=M103
L=0.15
W=0.36
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 7260 -60 2 0 {name=l131 sig_type=std_logic lab=GND}
C {gnd.sym} 7260 -30 0 0 {name=l132 lab=GND}
C {lab_pin.sym} 7260 -250 1 0 {name=l133 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 7260 -140 2 0 {name=l134 sig_type=std_logic lab=FvcoBUF}
C {xschem_sky130/sky130_fd_pr/pfet_01v8_lvt.sym} 450 1070 0 1 {name=M105
L=1
W=5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {res.sym} 430 1010 0 1 {name=R13
value=110k
footprint=1206
device=resistor
m=1}
C {xschem_sky130/sky130_fd_pr/pfet_01v8_lvt.sym} 770 1070 0 0 {name=M106
L=1
W=5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {res.sym} 790 1010 0 0 {name=R14
value=110k
footprint=1206
device=resistor
m=1}
C {vsource.sym} 590 1040 2 0 {name=V15 value=0.8}
C {gnd.sym} 590 1010 2 0 {name=l151 lab=GND}
C {xschem_sky130/sky130_fd_pr/pfet_01v8_lvt.sym} 450 1230 0 1 {name=M107
L=1
W=10
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet_01v8_lvt.sym} 770 1230 0 0 {name=M108
L=1
W=10
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet_01v8_lvt.sym} 450 1360 0 1 {name=M109
L=1
W=12
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet_01v8_lvt.sym} 770 1360 0 0 {name=M110
L=1
W=12
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet_01v8_lvt.sym} 450 1570 0 1 {name=M111
L=2
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet_01v8_lvt.sym} 770 1570 0 0 {name=M112
L=2
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {gnd.sym} 790 1570 3 0 {name=l152 lab=GND}
C {gnd.sym} 430 1570 1 0 {name=l161 lab=GND}
C {gnd.sym} 430 1360 1 0 {name=l167 lab=GND}
C {gnd.sym} 790 1360 3 0 {name=l168 lab=GND}
C {res.sym} 430 1630 0 1 {name=R15
value=55k
footprint=1206
device=resistor
m=1}
C {res.sym} 790 1630 0 1 {name=R16
value=55k
footprint=1206
device=resistor
m=1}
C {gnd.sym} 430 1660 0 0 {name=l169 lab=GND}
C {gnd.sym} 790 1660 0 0 {name=l170 lab=GND}
C {vsource.sym} 560 860 2 0 {name=V16 value=1.8}
C {gnd.sym} 560 830 2 0 {name=l171 lab=GND}
C {vsource.sym} 840 1290 3 0 {name=V17 value=0}
C {vsource.sym} 400 1300 1 0 {name=V18 value=0}
C {vsource.sym} 760 1330 3 0 {name=V19 value=0}
C {vsource.sym} 760 1260 1 0 {name=V20 value=0}
C {vsource.sym} 400 1260 1 0 {name=V21 value=0}
C {xschem_sky130/sky130_fd_pr/nfet_01v8_lvt.sym} 1140 830 0 1 {name=M113
L=4
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet_01v8_lvt.sym} 1140 720 0 1 {name=M114
L=1
W=10
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet_01v8_lvt.sym} 1320 720 0 0 {name=M115
L=1
W=10
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet_01v8_lvt.sym} 1320 830 0 0 {name=M116
L=4
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {gnd.sym} 1120 860 0 0 {name=l173 lab=GND}
C {gnd.sym} 1340 860 0 0 {name=l174 lab=GND}
C {gnd.sym} 1340 830 3 0 {name=l175 lab=GND}
C {vsource.sym} 1210 540 2 0 {name=V23 value=1.8}
C {gnd.sym} 1210 510 2 0 {name=l176 lab=GND}
C {vsource.sym} 1220 860 0 0 {name=V24 value=0.561}
C {gnd.sym} 1220 890 0 0 {name=l177 lab=GND}
C {res.sym} 1210 600 0 0 {name=R17
value=165k
footprint=1206
device=resistor
m=1}
C {xschem_sky130/sky130_fd_pr/nfet_01v8_lvt.sym} 1180 1670 0 1 {name=M117
L=1
W=36
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet_01v8_lvt.sym} 1370 1670 0 0 {name=M118
L=1
W=36
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet_01v8_lvt.sym} 1180 1540 0 1 {name=M119
L=2
W=5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet_01v8_lvt.sym} 1370 1540 0 0 {name=M120
L=2
W=5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {res.sym} 1270 1760 0 0 {name=R18
value=165k
footprint=1206
device=resistor
m=1}
C {res.sym} 1160 1420 0 0 {name=R19
value=330k
footprint=1206
device=resistor
m=1}
C {res.sym} 1390 1420 0 0 {name=R20
value=330k
footprint=1206
device=resistor
m=1}
C {gnd.sym} 1270 1790 0 0 {name=l178 lab=GND}
C {vsource.sym} 1080 1400 0 0 {name=V25 value=1.8}
C {gnd.sym} 1080 1430 0 0 {name=l179 lab=GND}
C {vsource.sym} 1270 1570 0 0 {name=V26 value=1.08}
C {gnd.sym} 1270 1600 0 0 {name=l180 lab=GND}
C {gnd.sym} 1430 1670 0 0 {name=l181 lab=GND}
C {gnd.sym} 1120 1670 0 0 {name=l182 lab=GND}
C {lab_pin.sym} 1160 720 2 0 {name=l183 sig_type=std_logic lab=vinp1}
C {lab_pin.sym} 1300 720 0 0 {name=l184 sig_type=std_logic lab=vinp2}
C {lab_pin.sym} 1370 770 2 0 {name=l185 sig_type=std_logic lab=outpch2}
C {lab_pin.sym} 1170 770 2 0 {name=l186 sig_type=std_logic lab=outpch1}
C {lab_pin.sym} 430 1130 2 0 {name=l187 sig_type=std_logic lab=vinp1}
C {lab_pin.sym} 790 1120 0 0 {name=l188 sig_type=std_logic lab=vinp2}
C {lab_pin.sym} 470 1230 2 0 {name=l189 sig_type=std_logic lab=outp1}
C {lab_pin.sym} 750 1230 0 0 {name=l190 sig_type=std_logic lab=outp2}
C {lab_pin.sym} 1200 1670 2 0 {name=l191 sig_type=std_logic lab=vinnch1}
C {lab_pin.sym} 1350 1670 0 0 {name=l192 sig_type=std_logic lab=vinnch2}
C {lab_pin.sym} 1120 1600 0 0 {name=l193 sig_type=std_logic lab=outnch1}
C {lab_pin.sym} 1430 1600 2 0 {name=l194 sig_type=std_logic lab=outnch2}
C {lab_pin.sym} 470 1360 2 0 {name=l195 sig_type=std_logic lab=outn1}
C {lab_pin.sym} 750 1360 0 0 {name=l196 sig_type=std_logic lab=outn2}
C {lab_pin.sym} 500 1310 2 0 {name=l197 sig_type=std_logic lab=Bout_mirror}
C {lab_pin.sym} 730 1300 0 0 {name=l198 sig_type=std_logic lab=Bout}
C {lab_pin.sym} 430 1420 0 0 {name=l199 sig_type=std_logic lab=vinn1}
C {lab_pin.sym} 790 1420 0 0 {name=l200 sig_type=std_logic lab=vinn2}
C {lab_pin.sym} 430 1490 0 0 {name=l201 sig_type=std_logic lab=vinnch1}
C {lab_pin.sym} 790 1510 0 0 {name=l202 sig_type=std_logic lab=vinnch2}
C {lab_pin.sym} 430 1180 2 0 {name=l203 sig_type=std_logic lab=vinpch1}
C {lab_pin.sym} 790 1180 0 0 {name=l204 sig_type=std_logic lab=vinpch2}
C {xschem_sky130/sky130_fd_pr/nfet3_01v8.sym} -610 990 0 1 {name=M121
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet3_01v8.sym} -790 990 0 0 {name=M122
L=0.15
W=1
body=VDD
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet3_01v8.sym} -30 980 0 1 {name=M123
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet3_01v8.sym} -210 980 0 0 {name=M124
L=0.15
W=1
body=VDD
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet3_01v8.sym} -440 890 1 1 {name=M125
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet3_01v8.sym} -440 710 1 0 {name=M126
L=0.15
W=1
body=VDD
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet3_01v8.sym} -440 1230 1 1 {name=M127
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet3_01v8.sym} -440 1050 1 0 {name=M128
L=0.15
W=1
body=VDD
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} -710 900 1 0 {name=l205 sig_type=std_logic lab=vinp1}
C {lab_pin.sym} -710 1070 3 0 {name=l206 sig_type=std_logic lab=vinpch1}
C {lab_pin.sym} -350 1130 1 0 {name=l207 sig_type=std_logic lab=vinp2}
C {lab_pin.sym} -130 1060 3 0 {name=l208 sig_type=std_logic lab=vinpch2}
C {xschem_sky130/sky130_fd_pr/nfet3_01v8.sym} -670 1740 0 1 {name=M129
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet3_01v8.sym} -850 1740 0 0 {name=M130
L=0.15
W=1
body=VDD
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet3_01v8.sym} -90 1730 0 1 {name=M131
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet3_01v8.sym} -270 1730 0 0 {name=M132
L=0.15
W=1
body=VDD
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet3_01v8.sym} -500 1640 1 1 {name=M133
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet3_01v8.sym} -500 1460 1 0 {name=M134
L=0.15
W=1
body=VDD
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet3_01v8.sym} -500 1980 1 1 {name=M135
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet3_01v8.sym} -500 1800 1 0 {name=M136
L=0.15
W=1
body=VDD
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} -770 1650 1 0 {name=l209 sig_type=std_logic lab=vinn1}
C {lab_pin.sym} -770 1820 3 0 {name=l210 sig_type=std_logic lab=vinnch1}
C {lab_pin.sym} -410 1880 1 0 {name=l211 sig_type=std_logic lab=vinn2}
C {lab_pin.sym} -190 1810 3 0 {name=l212 sig_type=std_logic lab=vinnch2}
C {xschem_sky130/sky130_fd_pr/nfet3_01v8.sym} 1860 920 0 1 {name=M137
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet3_01v8.sym} 1680 920 0 0 {name=M138
L=0.15
W=1
body=VDD
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet3_01v8.sym} 2440 910 0 1 {name=M139
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet3_01v8.sym} 2260 910 0 0 {name=M140
L=0.15
W=1
body=VDD
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet3_01v8.sym} 2030 820 1 1 {name=M141
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet3_01v8.sym} 2030 640 1 0 {name=M142
L=0.15
W=1
body=VDD
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet3_01v8.sym} 2030 1160 1 1 {name=M143
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet3_01v8.sym} 2030 980 1 0 {name=M144
L=0.15
W=1
body=VDD
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 1760 830 1 0 {name=l213 sig_type=std_logic lab=outpch1}
C {lab_pin.sym} 1760 1000 3 0 {name=l214 sig_type=std_logic lab=outp1}
C {lab_pin.sym} 2120 1060 1 0 {name=l215 sig_type=std_logic lab=outpch2}
C {lab_pin.sym} 2340 990 3 0 {name=l216 sig_type=std_logic lab=outp2}
C {xschem_sky130/sky130_fd_pr/nfet3_01v8.sym} 1830 1720 0 1 {name=M145
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet3_01v8.sym} 1650 1720 0 0 {name=M146
L=0.15
W=1
body=VDD
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet3_01v8.sym} 2410 1710 0 1 {name=M147
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet3_01v8.sym} 2230 1710 0 0 {name=M148
L=0.15
W=1
body=VDD
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet3_01v8.sym} 2000 1620 1 1 {name=M149
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet3_01v8.sym} 2000 1440 1 0 {name=M150
L=0.15
W=1
body=VDD
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet3_01v8.sym} 2000 1960 1 1 {name=M151
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet3_01v8.sym} 2000 1780 1 0 {name=M152
L=0.15
W=1
body=VDD
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 1730 1630 1 0 {name=l217 sig_type=std_logic lab=outnch1}
C {lab_pin.sym} 1730 1800 3 0 {name=l218 sig_type=std_logic lab=outn1}
C {lab_pin.sym} 2090 1860 1 0 {name=l219 sig_type=std_logic lab=outnch2}
C {lab_pin.sym} 2310 1790 3 0 {name=l220 sig_type=std_logic lab=outn2}
C {lab_pin.sym} -940 1740 0 0 {name=l2 sig_type=std_logic lab=FvcoBy4_QPH_bar}
C {lab_pin.sym} -860 990 0 0 {name=l3 sig_type=std_logic lab=FvcoBy4_QPH_bar}
C {lab_pin.sym} 1580 920 0 0 {name=l4 sig_type=std_logic lab=FvcoBy4_QPH_bar}
C {lab_pin.sym} 1570 1720 3 0 {name=l5 sig_type=std_logic lab=FvcoBy4_QPH_bar}
C {lab_pin.sym} -850 1190 0 0 {name=l6 sig_type=std_logic lab=FvcoBy4_QPH}
C {lab_pin.sym} -930 1950 0 0 {name=l7 sig_type=std_logic lab=FvcoBy4_QPH}
C {lab_pin.sym} 1560 1910 0 0 {name=l8 sig_type=std_logic lab=FvcoBy4_QPH}
C {lab_pin.sym} 1580 1100 0 0 {name=l9 sig_type=std_logic lab=FvcoBy4_QPH}
C {xschem_sky130/sky130_fd_pr/pfet_01v8_lvt.sym} 4570 -550 0 0 {name=M2
L=cl1
W=cw1
nf=1
mult=m1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet_01v8_lvt.sym} 4570 -420 0 0 {name=M3
L=cl2
W=cw2
nf=1
mult=m2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {gnd.sym} 4590 -200 0 0 {name=l1 lab=GND}
C {xschem_sky130/sky130_fd_pr/pfet_01v8_lvt.sym} 4570 -740 0 0 {name=M1
L=cl
W=cw
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {gnd.sym} 4860 -200 0 0 {name=l10 lab=GND}
C {gnd.sym} 5130 -200 0 0 {name=l11 lab=GND}
C {gnd.sym} 5400 -200 0 0 {name=l12 lab=GND}
C {gnd.sym} 5670 -200 0 0 {name=l13 lab=GND}
C {gnd.sym} 5940 -200 0 0 {name=l14 lab=GND}
C {gnd.sym} 6210 -200 0 0 {name=l16 lab=GND}
C {gnd.sym} 6480 -200 0 0 {name=l18 lab=GND}
C {gnd.sym} 6750 -200 0 0 {name=l20 lab=GND}
C {xschem_sky130/sky130_fd_pr/pfet_01v8_lvt.sym} 4840 -550 0 0 {name=M5
L=cl1
W=cw1
nf=1
mult=m1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet_01v8_lvt.sym} 5110 -550 0 0 {name=M8
L=cl1
W=cw1
nf=1
mult=m1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet_01v8_lvt.sym} 5380 -550 0 0 {name=M11
L=cl1
W=cw1
nf=1
mult=m1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet_01v8_lvt.sym} 5650 -550 0 0 {name=M4
L=cl1
W=cw1
nf=1
mult=m1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet_01v8_lvt.sym} 5920 -550 0 0 {name=M6
L=cl1
W=cw1
nf=1
mult=m1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet_01v8_lvt.sym} 6190 -550 0 0 {name=M7
L=cl1
W=cw1
nf=1
mult=m1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet_01v8_lvt.sym} 6460 -550 0 0 {name=M9
L=cl1
W=cw1
nf=1
mult=m1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet_01v8_lvt.sym} 6730 -550 0 0 {name=M10
L=cl1
W=cw1
nf=1
mult=m1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {lab_pin.sym} 4470 -1250 1 0 {name=l15 sig_type=std_logic lab=VDD}
C {gnd.sym} 4470 -1190 0 0 {name=l17 lab=GND}
C {lab_pin.sym} 4590 -550 2 0 {name=l19 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 4860 -550 2 0 {name=l21 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 5130 -550 2 0 {name=l22 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 5400 -550 2 0 {name=l24 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 5670 -550 2 0 {name=l26 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 5940 -550 2 0 {name=l27 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 6480 -550 2 0 {name=l28 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 6750 -550 2 0 {name=l29 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 6210 -550 2 0 {name=l31 sig_type=std_logic lab=VDD}
C {xschem_sky130/sky130_fd_pr/nfet_01v8_lvt.sym} 4570 -290 0 0 {name=M28
L=cl3
W=cw3
nf=1
mult=m3
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet_01v8_lvt.sym} 4840 -420 0 0 {name=M38
L=cl2
W=cw2
nf=1
mult=m2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet_01v8_lvt.sym} 5110 -420 0 0 {name=M39
L=cl2
W=cw2
nf=1
mult=m2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet_01v8_lvt.sym} 5380 -420 0 0 {name=M40
L=cl2
W=cw2
nf=1
mult=m2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet_01v8_lvt.sym} 5650 -420 0 0 {name=M41
L=cl2
W=cw2
nf=1
mult=m2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet_01v8_lvt.sym} 5920 -420 0 0 {name=M42
L=cl2
W=cw2
nf=1
mult=m2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet_01v8_lvt.sym} 6190 -420 0 0 {name=M43
L=cl2
W=cw2
nf=1
mult=m2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet_01v8_lvt.sym} 6460 -420 0 0 {name=M44
L=cl2
W=cw2
nf=1
mult=m2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet_01v8_lvt.sym} 6730 -420 0 0 {name=M45
L=cl2
W=cw2
nf=1
mult=m2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet_01v8_lvt.sym} 4840 -290 0 0 {name=M46
L=cl3
W=cw3
nf=1
mult=m3
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet_01v8_lvt.sym} 5110 -290 0 0 {name=M47
L=cl3
W=cw3
nf=1
mult=m3
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet_01v8_lvt.sym} 5380 -290 0 0 {name=M48
L=cl3
W=cw3
nf=1
mult=m3
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet_01v8_lvt.sym} 5650 -290 0 0 {name=M49
L=cl3
W=cw3
nf=1
mult=m3
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet_01v8_lvt.sym} 5920 -290 0 0 {name=M50
L=cl3
W=cw3
nf=1
mult=m3
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet_01v8_lvt.sym} 6190 -290 0 0 {name=M51
L=cl3
W=cw3
nf=1
mult=m3
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet_01v8_lvt.sym} 6460 -290 0 0 {name=M52
L=cl3
W=cw3
nf=1
mult=m3
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet_01v8_lvt.sym} 6730 -290 0 0 {name=M53
L=cl3
W=cw3
nf=1
mult=m3
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {lab_pin.sym} 4620 -930 1 0 {name=l35 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 6750 -470 0 0 {name=l37 sig_type=std_logic lab=Fvco}
C {lab_pin.sym} 4500 -460 0 0 {name=l38 sig_type=std_logic lab=Fvco}
C {capa.sym} 4740 -620 0 0 {name=C5
m=1
value=20p
footprint=1206
device="ceramic capacitor"}
C {gnd.sym} 4740 -590 1 0 {name=l39 lab=GND}
C {xschem_sky130/sky130_fd_pr/pfet_01v8_lvt.sym} 4750 -730 0 0 {name=M54
L=1
W=10
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {vsource.sym} 4700 -730 1 0 {name=V1 value="pulse(1.8 0 0 1n 1n 0.1u)"}
C {gnd.sym} 4670 -730 1 0 {name=l40 lab=GND}
C {vsource.sym} 7130 -640 0 0 {name=V3 value="pwl(0.000us 0.0V, 
+ 0.500us 0.0V, 0.501us 1.8V,
+ 1.500us 1.8V, 1.501us 0.0V)"
}
C {gnd.sym} 7130 -610 0 0 {name=l34 lab=GND}
C {lab_wire.sym} 7470 -720 0 1 {name=p5 lab=FvcoBy2}
C {lab_wire.sym} 7470 -630 0 1 {name=p6 lab=xTSPC_Dff1_Q_bar}
C {lab_wire.sym} 7870 -720 0 1 {name=p1 lab=FvcoBy4_IPH}
C {lab_wire.sym} 7870 -630 0 1 {name=p3 lab=FvcoBy4_IPH_bar}
C {lab_wire.sym} 8300 -430 0 1 {name=p9 lab=FvcoBy4_QPH}
C {lab_wire.sym} 8300 -340 0 1 {name=p10 lab=FvcoBy4_QPH_bar}
C {lab_pin.sym} 8170 -380 0 0 {name=l36 sig_type=std_logic lab=vclear}
C {lab_pin.sym} 7340 -670 0 0 {name=l41 sig_type=std_logic lab=vclear}
C {lab_pin.sym} 7740 -670 0 0 {name=l42 sig_type=std_logic lab=vclear}
C {/home/dhurga/MUX_risingEdge_Dff_with_asynch_clear.sym} 7810 -670 0 0 {name=xMUX_risingEdge_Dff1 m=1
+ VDDPIN=VDD VSSPIN=GND
+ wnmos=0.42 lnmos=0.15
+ wpmos=1.68 lpmos=0.15}
C {/home/dhurga/MUX_risingEdge_Dff_with_asynch_clear.sym} 7410 -670 0 0 {name=xMUX_risingEdge_Dff5 m=1
+ VDDPIN=VDD VSSPIN=GND
+ wnmos=0.42 lnmos=0.15
+ wpmos=1.68 lpmos=0.15}
C {/home/dhurga/MUX_risingEdge_Dff_with_asynch_clear.sym} 8240 -380 0 0 {name=xMUX_risingEdge_Dff6 m=1
+ VDDPIN=VDD VSSPIN=GND
+ wnmos=0.42 lnmos=0.15
+ wpmos=1.68 lpmos=0.15}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 7880 -530 0 0 {name=M12
L=0.15
W=1.68
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet_01v8.sym} 7880 -370 0 0 {name=M13
L=0.15
W=0.36
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 7900 -370 2 0 {name=l23 sig_type=std_logic lab=GND}
C {gnd.sym} 7900 -340 0 0 {name=l43 lab=GND}
C {lab_pin.sym} 7900 -560 1 0 {name=l44 sig_type=std_logic lab=VDD}
C {xschem_sky130/sky130_fd_pr/cap_mim_m3_1.sym} -530 -80 3 0 {name=C7 model=cap_mim_m3_1 W=24 L=24.1 MF=4 spiceprefix=X}
C {xschem_sky130/sky130_fd_pr/res_xhigh_po_0p35.sym} -640 -80 3 0 {name=R1
W=0.35
L=23.625
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {xschem_sky130/sky130_fd_pr/res_xhigh_po_0p35.sym} -640 90 3 0 {name=R2
W=0.35
L=23.625
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {xschem_sky130/sky130_fd_pr/res_xhigh_po_0p35.sym} -380 -80 3 0 {name=R7
W=0.35
L=23.625
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {xschem_sky130/sky130_fd_pr/res_xhigh_po_0p35.sym} -380 90 3 0 {name=R8
W=0.35
L=23.625
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {gnd.sym} -640 -60 0 0 {name=l45 lab=GND}
C {gnd.sym} -380 -60 0 0 {name=l46 lab=GND}
C {xschem_sky130/sky130_fd_pr/cap_mim_m3_1.sym} -530 90 3 0 {name=C8 model=cap_mim_m3_1 W=24 L=24.1 MF=4 spiceprefix=X}
C {xschem_sky130/sky130_fd_pr/cap_mim_m3_1.sym} -500 0 0 0 {name=C9 model=cap_mim_m3_1 W=24 L=24.1 MF=2 spiceprefix=X}
C {vsource.sym} -300 90 3 0 {name=vin3 value="0" net_name=true

}
C {vsource.sym} -290 -80 3 0 {name=vin4 value="0" net_name=true

}
C {lab_pin.sym} -710 120 3 0 {name=l49 sig_type=std_logic lab=FvcoBy4_IPH_bar}
C {lab_pin.sym} -690 -110 1 0 {name=l50 sig_type=std_logic lab=FvcoBy4_IPH}
C {lab_pin.sym} -250 -80 1 0 {name=l47 sig_type=std_logic lab=vinp2}
C {lab_pin.sym} -240 90 1 0 {name=l48 sig_type=std_logic lab=vinp1}
C {gnd.sym} -640 110 0 0 {name=l30 lab=GND}
C {gnd.sym} -380 110 0 0 {name=l32 lab=GND}
C {lab_pin.sym} 4230 -740 1 0 {name=l33 sig_type=std_logic lab=vctrl
}
C {xschem_sky130/sky130_fd_pr/nfet3_01v8.sym} 1760 -360 0 1 {name=M16
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet3_01v8.sym} 1580 -360 0 0 {name=M17
L=0.15
W=1
body=VDD
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 1780 -360 2 0 {name=l56 sig_type=std_logic lab=FvcoBy4_IPH}
C {lab_pin.sym} 1550 -360 0 0 {name=l57 sig_type=std_logic lab=FvcoBy4_IPH_bar}
C {xschem_sky130/sky130_fd_pr/nfet3_01v8.sym} 2440 60 0 1 {name=M18
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet3_01v8.sym} 2260 60 0 0 {name=M19
L=0.15
W=1
body=VDD
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 2460 60 2 0 {name=l55 sig_type=std_logic lab=FvcoBy4_IPH}
C {lab_pin.sym} 2230 60 0 0 {name=l58 sig_type=std_logic lab=FvcoBy4_IPH_bar}
C {xschem_sky130/sky130_fd_pr/nfet3_01v8.sym} 1760 140 0 1 {name=M20
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet3_01v8.sym} 1580 140 0 0 {name=M21
L=0.15
W=1
body=VDD
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 1550 140 0 0 {name=l59 sig_type=std_logic lab=FvcoBy4_IPH}
C {lab_pin.sym} 1780 140 2 0 {name=l60 sig_type=std_logic lab=FvcoBy4_IPH_bar}
C {xschem_sky130/sky130_fd_pr/nfet3_01v8.sym} 2430 -340 0 1 {name=M22
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet3_01v8.sym} 2250 -340 0 0 {name=M23
L=0.15
W=1
body=VDD
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 2220 -340 0 0 {name=l61 sig_type=std_logic lab=FvcoBy4_IPH}
C {lab_pin.sym} 2450 -340 2 0 {name=l62 sig_type=std_logic lab=FvcoBy4_IPH_bar}
C {xschem_sky130/sky130_fd_pr/pfet_01v8_lvt.sym} 2020 -520 3 0 {name=M24
L=8
W=7
nf=1
mult=200
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet_01v8_lvt.sym} 2000 -110 3 0 {name=M25
L=8
W=7
nf=1
mult=200
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {lab_pin.sym} 2610 -450 2 0 {name=l63 sig_type=std_logic lab=vctrl
}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 5700 230 0 0 {name=M70
L=0.15
W=1.68
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet_01v8.sym} 5700 390 0 0 {name=M71
L=0.15
W=0.36
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 5720 390 2 0 {name=l25 sig_type=std_logic lab=GND}
C {gnd.sym} 5720 420 0 0 {name=l51 lab=GND}
C {lab_pin.sym} 5720 200 1 0 {name=l52 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 5660 340 0 0 {name=l53 sig_type=std_logic lab=n5}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 5990 230 0 0 {name=M72
L=0.15
W=1.68
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet_01v8.sym} 5990 390 0 0 {name=M73
L=0.15
W=0.36
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 6010 390 2 0 {name=l54 sig_type=std_logic lab=GND}
C {gnd.sym} 6010 420 0 0 {name=l81 lab=GND}
C {lab_pin.sym} 6010 200 1 0 {name=l82 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 6010 310 2 0 {name=l83 sig_type=std_logic lab=FvcoBUF5}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 6390 200 0 0 {name=M74
L=0.15
W=1.68
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet_01v8.sym} 6390 360 0 0 {name=M75
L=0.15
W=0.36
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 6410 360 2 0 {name=l84 sig_type=std_logic lab=GND}
C {gnd.sym} 6410 390 0 0 {name=l85 lab=GND}
C {lab_pin.sym} 6410 170 1 0 {name=l86 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 6350 310 0 0 {name=l87 sig_type=std_logic lab=n6}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 6680 200 0 0 {name=M76
L=0.15
W=1.68
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet_01v8.sym} 6680 360 0 0 {name=M77
L=0.15
W=0.36
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 6700 360 2 0 {name=l88 sig_type=std_logic lab=GND}
C {gnd.sym} 6700 390 0 0 {name=l89 lab=GND}
C {lab_pin.sym} 6700 170 1 0 {name=l90 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 6700 280 2 0 {name=l91 sig_type=std_logic lab=FvcoBUF6}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 7040 200 0 0 {name=M78
L=0.15
W=1.68
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet_01v8.sym} 7040 360 0 0 {name=M79
L=0.15
W=0.36
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 7060 360 2 0 {name=l92 sig_type=std_logic lab=GND}
C {gnd.sym} 7060 390 0 0 {name=l96 lab=GND}
C {lab_pin.sym} 7060 170 1 0 {name=l109 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 7000 310 0 0 {name=l145 sig_type=std_logic lab=n7}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 7330 200 0 0 {name=M80
L=0.15
W=1.68
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet_01v8.sym} 7330 360 0 0 {name=M81
L=0.15
W=0.36
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 7350 360 2 0 {name=l146 sig_type=std_logic lab=GND}
C {gnd.sym} 7350 390 0 0 {name=l147 lab=GND}
C {lab_pin.sym} 7350 170 1 0 {name=l148 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 7350 280 2 0 {name=l149 sig_type=std_logic lab=FvcoBUF7}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 7640 190 0 0 {name=M82
L=0.15
W=1.68
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet_01v8.sym} 7640 350 0 0 {name=M83
L=0.15
W=0.36
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 7660 350 2 0 {name=l150 sig_type=std_logic lab=GND}
C {gnd.sym} 7660 380 0 0 {name=l153 lab=GND}
C {lab_pin.sym} 7660 160 1 0 {name=l154 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 7600 300 0 0 {name=l155 sig_type=std_logic lab=n8}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 7930 190 0 0 {name=M84
L=0.15
W=1.68
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet_01v8.sym} 7930 350 0 0 {name=M85
L=0.15
W=0.36
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 7950 350 2 0 {name=l156 sig_type=std_logic lab=GND}
C {gnd.sym} 7950 380 0 0 {name=l157 lab=GND}
C {lab_pin.sym} 7950 160 1 0 {name=l158 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 7950 270 2 0 {name=l159 sig_type=std_logic lab=FvcoBUF8}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 8250 190 0 0 {name=M86
L=0.15
W=1.68
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet_01v8.sym} 8250 350 0 0 {name=M87
L=0.15
W=0.36
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 8270 350 2 0 {name=l160 sig_type=std_logic lab=GND}
C {gnd.sym} 8270 380 0 0 {name=l162 lab=GND}
C {lab_pin.sym} 8270 160 1 0 {name=l163 sig_type=std_logic lab=VDD}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 8540 190 0 0 {name=M155
L=0.15
W=1.68
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet_01v8.sym} 8540 350 0 0 {name=M156
L=0.15
W=0.36
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 8560 350 2 0 {name=l165 sig_type=std_logic lab=GND}
C {gnd.sym} 8560 380 0 0 {name=l166 lab=GND}
C {lab_pin.sym} 8560 160 1 0 {name=l172 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 8560 270 2 0 {name=l221 sig_type=std_logic lab=FvcoBUF9}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 5080 250 0 0 {name=M157
L=0.15
W=1.68
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet_01v8.sym} 5080 410 0 0 {name=M158
L=0.15
W=0.36
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 5100 410 2 0 {name=l222 sig_type=std_logic lab=GND}
C {gnd.sym} 5100 440 0 0 {name=l223 lab=GND}
C {lab_pin.sym} 5100 220 1 0 {name=l224 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 5040 360 0 0 {name=l225 sig_type=std_logic lab=n4}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 5370 250 0 0 {name=M159
L=0.15
W=1.68
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet_01v8.sym} 5370 410 0 0 {name=M160
L=0.15
W=0.36
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 5390 410 2 0 {name=l226 sig_type=std_logic lab=GND}
C {gnd.sym} 5390 440 0 0 {name=l227 lab=GND}
C {lab_pin.sym} 5390 220 1 0 {name=l228 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 5390 330 2 0 {name=l229 sig_type=std_logic lab=FvcoBUF4}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 4500 240 0 0 {name=M161
L=0.15
W=1.68
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet_01v8.sym} 4500 400 0 0 {name=M162
L=0.15
W=0.36
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 4520 400 2 0 {name=l230 sig_type=std_logic lab=GND}
C {gnd.sym} 4520 430 0 0 {name=l231 lab=GND}
C {lab_pin.sym} 4520 210 1 0 {name=l232 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 4460 350 0 0 {name=l233 sig_type=std_logic lab=n3}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 4790 240 0 0 {name=M163
L=0.15
W=1.68
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet_01v8.sym} 4790 400 0 0 {name=M164
L=0.15
W=0.36
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 4810 400 2 0 {name=l234 sig_type=std_logic lab=GND}
C {gnd.sym} 4810 430 0 0 {name=l235 lab=GND}
C {lab_pin.sym} 4810 210 1 0 {name=l236 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 4810 320 2 0 {name=l237 sig_type=std_logic lab=FvcoBUF3}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 3890 270 0 0 {name=M165
L=0.15
W=1.68
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet_01v8.sym} 3890 430 0 0 {name=M166
L=0.15
W=0.36
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 3910 430 2 0 {name=l238 sig_type=std_logic lab=GND}
C {gnd.sym} 3910 460 0 0 {name=l239 lab=GND}
C {lab_pin.sym} 3910 240 1 0 {name=l240 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 3850 380 0 0 {name=l241 sig_type=std_logic lab=n2}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 4180 270 0 0 {name=M168
L=0.15
W=1.68
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet_01v8.sym} 4180 430 0 0 {name=M169
L=0.15
W=0.36
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 4200 430 2 0 {name=l242 sig_type=std_logic lab=GND}
C {gnd.sym} 4200 460 0 0 {name=l243 lab=GND}
C {lab_pin.sym} 4200 240 1 0 {name=l244 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 4200 350 2 0 {name=l245 sig_type=std_logic lab=FvcoBUF2}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 3340 280 0 0 {name=M170
L=0.15
W=1.68
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet_01v8.sym} 3340 440 0 0 {name=M171
L=0.15
W=0.36
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 3360 440 2 0 {name=l246 sig_type=std_logic lab=GND}
C {gnd.sym} 3360 470 0 0 {name=l247 lab=GND}
C {lab_pin.sym} 3360 250 1 0 {name=l248 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 3300 390 0 0 {name=l249 sig_type=std_logic lab=n1}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 3630 280 0 0 {name=M172
L=0.15
W=1.68
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet_01v8.sym} 3630 440 0 0 {name=M173
L=0.15
W=0.36
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 3650 440 2 0 {name=l250 sig_type=std_logic lab=GND}
C {gnd.sym} 3650 470 0 0 {name=l251 lab=GND}
C {lab_pin.sym} 3650 250 1 0 {name=l252 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 3650 360 2 0 {name=l253 sig_type=std_logic lab=FvcoBUF1}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 5850 910 0 0 {name=M14
L=0.15
W=1.68
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 5950 910 0 0 {name=M15
L=0.15
W=1.68
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {gnd.sym} 5950 1130 0 0 {name=l67 lab=GND}
C {xschem_sky130/sky130_fd_pr/nfet_01v8.sym} 6250 1020 0 0 {name=M26
L=0.15
W=0.74
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet_01v8.sym} 6250 1090 0 0 {name=M27
L=0.15
W=0.74
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 6170 920 0 0 {name=M29
L=0.15
W=1.68
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 6270 920 0 0 {name=M30
L=0.15
W=1.68
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {gnd.sym} 6270 1140 0 0 {name=l68 lab=GND}
C {xschem_sky130/sky130_fd_pr/nfet_01v8.sym} 6610 1020 0 0 {name=M31
L=0.15
W=0.74
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet_01v8.sym} 6610 1090 0 0 {name=M32
L=0.15
W=0.74
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 6530 920 0 0 {name=M33
L=0.15
W=1.68
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 6630 920 0 0 {name=M34
L=0.15
W=1.68
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {gnd.sym} 6630 1140 0 0 {name=l69 lab=GND}
C {xschem_sky130/sky130_fd_pr/nfet_01v8.sym} 6970 1020 0 0 {name=M35
L=0.15
W=0.74
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet_01v8.sym} 6970 1090 0 0 {name=M36
L=0.15
W=0.74
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 6890 920 0 0 {name=M37
L=0.15
W=1.68
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 6990 920 0 0 {name=M55
L=0.15
W=1.68
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {gnd.sym} 6990 1140 0 0 {name=l70 lab=GND}
C {xschem_sky130/sky130_fd_pr/nfet_01v8.sym} 5930 1010 0 0 {name=M56
L=0.15
W=0.74
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet_01v8.sym} 5930 1080 0 0 {name=M57
L=0.15
W=0.74
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 5850 910 0 0 {name=M58
L=0.15
W=1.68
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 5950 910 0 0 {name=M59
L=0.15
W=1.68
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {gnd.sym} 5950 1130 0 0 {name=l71 lab=GND}
C {xschem_sky130/sky130_fd_pr/nfet_01v8.sym} 7330 1020 0 0 {name=M60
L=0.15
W=0.74
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet_01v8.sym} 7330 1090 0 0 {name=M61
L=0.15
W=0.74
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 7250 920 0 0 {name=M62
L=0.15
W=1.68
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 7350 920 0 0 {name=M63
L=0.15
W=1.68
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {gnd.sym} 7350 1140 0 0 {name=l72 lab=GND}
C {xschem_sky130/sky130_fd_pr/nfet_01v8.sym} 7670 1020 0 0 {name=M64
L=0.15
W=0.74
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet_01v8.sym} 7670 1090 0 0 {name=M65
L=0.15
W=0.74
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 7590 920 0 0 {name=M66
L=0.15
W=1.68
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 7690 920 0 0 {name=M67
L=0.15
W=1.68
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {gnd.sym} 7690 1140 0 0 {name=l73 lab=GND}
C {xschem_sky130/sky130_fd_pr/nfet_01v8.sym} 5600 1010 0 0 {name=M68
L=0.15
W=0.74
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet_01v8.sym} 5600 1080 0 0 {name=M69
L=0.15
W=0.74
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 5520 910 0 0 {name=M88
L=0.15
W=1.68
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 5620 910 0 0 {name=M89
L=0.15
W=1.68
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {gnd.sym} 5620 1130 0 0 {name=l74 lab=GND}
C {xschem_sky130/sky130_fd_pr/nfet_01v8.sym} 5260 1000 0 0 {name=M90
L=0.15
W=0.74
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet_01v8.sym} 5260 1070 0 0 {name=M91
L=0.15
W=0.74
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 5180 900 0 0 {name=M92
L=0.15
W=1.68
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 5280 900 0 0 {name=M93
L=0.15
W=1.68
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {gnd.sym} 5280 1120 0 0 {name=l75 lab=GND}
C {xschem_sky130/sky130_fd_pr/nfet_01v8.sym} 4930 1000 0 0 {name=M94
L=0.15
W=0.74
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet_01v8.sym} 4930 1070 0 0 {name=M95
L=0.15
W=0.74
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 4850 900 0 0 {name=M96
L=0.15
W=1.68
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 4950 900 0 0 {name=M97
L=0.15
W=1.68
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {gnd.sym} 4950 1120 0 0 {name=l76 lab=GND}
C {lab_pin.sym} 5070 950 1 0 {name=l77 sig_type=std_logic lab=v1}
C {lab_pin.sym} 5390 950 1 0 {name=l78 sig_type=std_logic lab=v2}
C {lab_pin.sym} 6060 960 1 0 {name=l79 sig_type=std_logic lab=v4}
C {lab_pin.sym} 6390 970 1 0 {name=l80 sig_type=std_logic lab=v5}
C {lab_pin.sym} 5720 960 1 0 {name=l93 sig_type=std_logic lab=v3
}
C {lab_pin.sym} 6740 970 1 0 {name=l94 sig_type=std_logic lab=v6}
C {lab_pin.sym} 7100 970 1 0 {name=l95 sig_type=std_logic lab=v7}
C {lab_pin.sym} 7470 970 1 0 {name=l97 sig_type=std_logic lab=v8}
C {lab_pin.sym} 7800 970 1 0 {name=l98 sig_type=std_logic lab=v9}
C {lab_pin.sym} 4710 1480 0 0 {name=l102 sig_type=std_logic lab=FvcoBUF9}
C {lab_pin.sym} 4910 840 1 0 {name=l112 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 5250 840 1 0 {name=l136 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 5580 850 1 0 {name=l137 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 5930 850 1 0 {name=l138 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 6230 860 1 0 {name=l139 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 6580 860 1 0 {name=l140 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 6950 860 1 0 {name=l141 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 7300 860 1 0 {name=l142 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 7640 860 1 0 {name=l143 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 4710 1000 0 0 {name=l99 sig_type=std_logic lab=FvcoBUF1}
C {lab_pin.sym} 4710 1120 0 0 {name=l100 sig_type=std_logic lab=FvcoBUF2}
C {lab_pin.sym} 4710 1220 0 0 {name=l101 sig_type=std_logic lab=FvcoBUF3}
C {lab_pin.sym} 4710 1260 0 0 {name=l103 sig_type=std_logic lab=FvcoBUF4}
C {lab_pin.sym} 4710 1300 0 0 {name=l104 sig_type=std_logic lab=FvcoBUF5}
C {lab_pin.sym} 4710 1340 0 0 {name=l105 sig_type=std_logic lab=FvcoBUF6}
C {lab_pin.sym} 4710 1380 0 0 {name=l106 sig_type=std_logic lab=FvcoBUF7}
C {lab_pin.sym} 4710 1430 0 0 {name=l107 sig_type=std_logic lab=FvcoBUF8}
C {lab_pin.sym} 4710 1510 0 0 {name=l108 sig_type=std_logic lab=FvcoBUF1}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 6020 1870 0 0 {name=M98
L=0.15
W=1.68
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet_01v8.sym} 6020 2030 0 0 {name=M99
L=0.15
W=0.36
nf=1 
mult=9
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 6040 2030 2 0 {name=l110 sig_type=std_logic lab=GND}
C {lab_pin.sym} 6040 1840 1 0 {name=l111 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 5980 1980 0 0 {name=l144 sig_type=std_logic lab=v1}
C {xschem_sky130/sky130_fd_pr/nfet_01v8.sym} 6020 2130 0 0 {name=M104
L=0.15
W=0.36
nf=1 
mult=9
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet_01v8.sym} 6020 2210 0 0 {name=M153
L=0.15
W=0.36
nf=1 
mult=9
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 6160 1870 0 0 {name=M154
L=0.15
W=1.68
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 6290 1870 0 0 {name=M167
L=0.15
W=1.68
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 6040 2210 2 0 {name=l254 sig_type=std_logic lab=GND}
C {lab_pin.sym} 6040 2130 2 0 {name=l255 sig_type=std_logic lab=GND}
C {lab_pin.sym} 6000 2130 0 0 {name=l256 sig_type=std_logic lab=v2}
C {lab_pin.sym} 6000 2210 0 0 {name=l257 sig_type=std_logic lab=v3}
C {lab_pin.sym} 6140 1870 0 0 {name=l259 sig_type=std_logic lab=v2}
C {lab_pin.sym} 6270 1870 0 0 {name=l260 sig_type=std_logic lab=v3}
C {xschem_sky130/sky130_fd_pr/nfet_01v8.sym} 6020 2290 0 0 {name=M174
L=0.15
W=0.36
nf=1 
mult=9
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 6040 2290 2 0 {name=l113 sig_type=std_logic lab=GND}
C {xschem_sky130/sky130_fd_pr/nfet_01v8.sym} 6020 2390 0 0 {name=M175
L=0.15
W=0.36
nf=1 
mult=9
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet_01v8.sym} 6020 2470 0 0 {name=M176
L=0.15
W=0.36
nf=1 
mult=9
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 6040 2470 2 0 {name=l114 sig_type=std_logic lab=GND}
C {lab_pin.sym} 6040 2390 2 0 {name=l115 sig_type=std_logic lab=GND}
C {lab_pin.sym} 6000 2390 0 0 {name=l116 sig_type=std_logic lab=v5}
C {lab_pin.sym} 6000 2470 0 0 {name=l117 sig_type=std_logic lab=v6}
C {xschem_sky130/sky130_fd_pr/nfet_01v8.sym} 6020 2590 0 0 {name=M177
L=0.15
W=0.36
nf=1 
mult=9
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 6040 2590 2 0 {name=l261 sig_type=std_logic lab=GND}
C {xschem_sky130/sky130_fd_pr/nfet_01v8.sym} 6020 2690 0 0 {name=M178
L=0.15
W=0.36
nf=1 
mult=9
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet_01v8.sym} 6020 2770 0 0 {name=M179
L=0.15
W=0.36
nf=1 
mult=9
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 6040 2770 2 0 {name=l262 sig_type=std_logic lab=GND}
C {lab_pin.sym} 6040 2690 2 0 {name=l263 sig_type=std_logic lab=GND}
C {lab_pin.sym} 6000 2690 0 0 {name=l264 sig_type=std_logic lab=v8}
C {lab_pin.sym} 6000 2770 0 0 {name=l265 sig_type=std_logic lab=v9}
C {lab_pin.sym} 5980 2290 0 0 {name=l266 sig_type=std_logic lab=v4}
C {lab_pin.sym} 5980 2590 0 0 {name=l267 sig_type=std_logic lab=v7}
C {gnd.sym} 6040 2800 0 0 {name=l268 lab=GND}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 6400 1870 0 0 {name=M180
L=0.15
W=1.68
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 6540 1870 0 0 {name=M181
L=0.15
W=1.68
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 6670 1870 0 0 {name=M182
L=0.15
W=1.68
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 6520 1870 0 0 {name=l270 sig_type=std_logic lab=v5}
C {lab_pin.sym} 6650 1870 0 0 {name=l271 sig_type=std_logic lab=v6}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 6780 1870 0 0 {name=M183
L=0.15
W=1.68
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 6920 1870 0 0 {name=M184
L=0.15
W=1.68
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 7050 1870 0 0 {name=M185
L=0.15
W=1.68
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 6900 1870 0 0 {name=l273 sig_type=std_logic lab=v8}
C {lab_pin.sym} 7030 1870 0 0 {name=l274 sig_type=std_logic lab=v9}
C {lab_pin.sym} 6360 1870 0 0 {name=l269 sig_type=std_logic lab=v4}
C {lab_pin.sym} 6740 1870 0 0 {name=l272 sig_type=std_logic lab=v7}
C {lab_pin.sym} 7070 1900 2 0 {name=l275 sig_type=std_logic lab=vout}
C {lab_pin.sym} 8210 280 0 0 {name=l118 sig_type=std_logic lab=Fvco}
C {lab_pin.sym} 4770 -340 0 0 {name=l119 sig_type=std_logic lab=n1}
C {lab_pin.sym} 5040 -350 0 0 {name=l120 sig_type=std_logic lab=n2}
C {lab_pin.sym} 5310 -360 0 0 {name=l121 sig_type=std_logic lab=n3}
C {lab_pin.sym} 5580 -360 0 0 {name=l122 sig_type=std_logic lab=n4}
C {lab_pin.sym} 5850 -360 0 0 {name=l123 sig_type=std_logic lab=n5}
C {lab_pin.sym} 6120 -370 0 0 {name=l125 sig_type=std_logic lab=n6}
C {lab_pin.sym} 6390 -350 0 0 {name=l126 sig_type=std_logic lab=n7}
C {lab_pin.sym} 6660 -340 0 0 {name=l127 sig_type=std_logic lab=n8}
C {vsource.sym} 4470 -1220 0 0 {name=V5 value="pwl(0.000us 0.0V,
+ 0.400us 0.0V, 1us 1.8V)"
}
C {gnd.sym} 2430 -690 0 0 {name=l65 lab=GND}
C {vsource.sym} 2430 -720 0 0 {name=V2 value="1.8V"
}
C {lab_pin.sym} 8800 1280 0 0 {name=l64 sig_type=std_logic lab=RESET}
C {lab_pin.sym} 8800 1240 0 0 {name=l66 sig_type=std_logic lab=vout}
C {lab_pin.sym} 8980 1240 2 0 {name=l135 sig_type=std_logic lab=out0}
C {lab_pin.sym} 9150 1280 0 0 {name=l164 sig_type=std_logic lab=RESET}
C {lab_pin.sym} 9330 1240 2 0 {name=l258 sig_type=std_logic lab=out1}
C {lab_pin.sym} 9570 1280 0 0 {name=l276 sig_type=std_logic lab=RESET}
C {lab_pin.sym} 9750 1240 2 0 {name=l277 sig_type=std_logic lab=out2}
C {lab_pin.sym} 9990 1280 0 0 {name=l278 sig_type=std_logic lab=RESET}
C {lab_pin.sym} 10170 1240 2 0 {name=l279 sig_type=std_logic lab=out3}
C {lab_pin.sym} 10390 1280 0 0 {name=l280 sig_type=std_logic lab=RESET}
C {lab_pin.sym} 10570 1240 2 0 {name=l281 sig_type=std_logic lab=out4}
C {lab_pin.sym} 10780 1280 0 0 {name=l282 sig_type=std_logic lab=RESET}
C {lab_pin.sym} 10960 1240 2 0 {name=l283 sig_type=std_logic lab=out5}
C {lab_pin.sym} 11130 1280 0 0 {name=l284 sig_type=std_logic lab=RESET}
C {lab_pin.sym} 11310 1240 2 0 {name=l285 sig_type=std_logic lab=out6}
C {lab_pin.sym} 11550 1280 0 0 {name=l286 sig_type=std_logic lab=RESET}
C {lab_pin.sym} 11730 1240 2 0 {name=l287 sig_type=std_logic lab=out7}
C {lab_pin.sym} 11970 1280 0 0 {name=l288 sig_type=std_logic lab=RESET}
C {lab_pin.sym} 12150 1240 2 0 {name=l289 sig_type=std_logic lab=out8}
C {lab_pin.sym} 12370 1280 0 0 {name=l290 sig_type=std_logic lab=RESET}
C {lab_pin.sym} 12550 1240 2 0 {name=l291 sig_type=std_logic lab=out9}
C {lab_pin.sym} 12800 1280 0 0 {name=l292 sig_type=std_logic lab=RESET}
C {lab_pin.sym} 12980 1240 2 0 {name=l293 sig_type=std_logic lab=out10}
C {lab_pin.sym} 13150 1280 0 0 {name=l294 sig_type=std_logic lab=RESET}
C {lab_pin.sym} 13330 1240 2 0 {name=l295 sig_type=std_logic lab=out11}
C {lab_pin.sym} 13570 1280 0 0 {name=l296 sig_type=std_logic lab=RESET}
C {lab_pin.sym} 13750 1240 2 0 {name=l297 sig_type=std_logic lab=out12}
C {lab_pin.sym} 13990 1280 0 0 {name=l298 sig_type=std_logic lab=RESET}
C {lab_pin.sym} 14170 1240 2 0 {name=l299 sig_type=std_logic lab=out13}
C {lab_pin.sym} 14390 1280 0 0 {name=l300 sig_type=std_logic lab=RESET}
C {lab_pin.sym} 14570 1240 2 0 {name=l301 sig_type=std_logic lab=out14}
C {lab_pin.sym} 14780 1280 0 0 {name=l302 sig_type=std_logic lab=RESET}
C {lab_pin.sym} 14960 1240 2 0 {name=l303 sig_type=std_logic lab=out15}
C {lab_pin.sym} 15130 1280 0 0 {name=l304 sig_type=std_logic lab=RESET}
C {lab_pin.sym} 15310 1240 2 0 {name=l305 sig_type=std_logic lab=out16}
C {lab_pin.sym} 15550 1280 0 0 {name=l306 sig_type=std_logic lab=RESET}
C {lab_pin.sym} 15730 1240 2 0 {name=l307 sig_type=std_logic lab=out17}
C {lab_pin.sym} 15970 1280 0 0 {name=l308 sig_type=std_logic lab=RESET}
C {lab_pin.sym} 16150 1240 2 0 {name=l309 sig_type=std_logic lab=out18}
C {lab_pin.sym} 16370 1280 0 0 {name=l310 sig_type=std_logic lab=RESET}
C {lab_pin.sym} 16550 1240 2 0 {name=l311 sig_type=std_logic lab=out19}
C {/home/dhurga/dfrbp_1.sym} 8890 1260 0 0 {name=x21 VGND=GND VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {/home/dhurga/dfrbp_1.sym} 9240 1260 0 0 {name=x1 VGND=GND VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {/home/dhurga/dfrbp_1.sym} 9660 1260 0 0 {name=x2 VGND=GND VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {/home/dhurga/dfrbp_1.sym} 10080 1260 0 0 {name=x3 VGND=GND VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {/home/dhurga/dfrbp_1.sym} 10480 1260 0 0 {name=x4 VGND=GND VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {/home/dhurga/dfrbp_1.sym} 10870 1260 0 0 {name=x5 VGND=GND VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {/home/dhurga/dfrbp_1.sym} 11220 1260 0 0 {name=x6 VGND=GND VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {/home/dhurga/dfrbp_1.sym} 11640 1260 0 0 {name=x7 VGND=GND VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {/home/dhurga/dfrbp_1.sym} 12060 1260 0 0 {name=x8 VGND=GND VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {/home/dhurga/dfrbp_1.sym} 12460 1260 0 0 {name=x9 VGND=GND VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {/home/dhurga/dfrbp_1.sym} 12890 1260 0 0 {name=x10 VGND=GND VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {/home/dhurga/dfrbp_1.sym} 13240 1260 0 0 {name=x11 VGND=GND VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {/home/dhurga/dfrbp_1.sym} 13660 1260 0 0 {name=x12 VGND=GND VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {/home/dhurga/dfrbp_1.sym} 14080 1260 0 0 {name=x13 VGND=GND VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {/home/dhurga/dfrbp_1.sym} 14480 1260 0 0 {name=x14 VGND=GND VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {/home/dhurga/dfrbp_1.sym} 14870 1260 0 0 {name=x15 VGND=GND VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {/home/dhurga/dfrbp_1.sym} 15220 1260 0 0 {name=x16 VGND=GND VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {/home/dhurga/dfrbp_1.sym} 15640 1260 0 0 {name=x17 VGND=GND VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {/home/dhurga/dfrbp_1.sym} 16060 1260 0 0 {name=x18 VGND=GND VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {/home/dhurga/dfrbp_1.sym} 16460 1260 0 0 {name=x19 VGND=GND VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {gnd.sym} 8660 1450 0 0 {name=l312 lab=GND}
C {vsource.sym} 8660 1420 0 0 {name=vin_pulse3 value="PULSE(0 1.8 0 100NS 100NS 22mS 44mS)" net_name=true

}
C {lab_pin.sym} 8690 1350 2 0 {name=l313 sig_type=std_logic lab=RESET}
