v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N 360 -570 420 -570 { lab=#net1}
N 420 -630 420 -570 { lab=#net1}
N 120 -630 420 -630 { lab=#net1}
N 120 -630 120 -570 { lab=#net1}
N 120 -570 180 -570 { lab=#net1}
N 420 -590 530 -590 { lab=#net1}
N 510 -570 530 -570 { lab=#net2}
N 510 -630 510 -570 { lab=#net2}
N 510 -630 780 -630 { lab=#net2}
N 780 -630 780 -570 { lab=#net2}
N 710 -570 780 -570 { lab=#net2}
N 930 -570 950 -570 { lab=#net3}
N 930 -630 930 -570 { lab=#net3}
N 930 -630 1200 -630 { lab=#net3}
N 1200 -630 1200 -570 { lab=#net3}
N 1130 -570 1200 -570 { lab=#net3}
N 1350 -570 1370 -570 { lab=#net4}
N 1350 -630 1350 -570 { lab=#net4}
N 1350 -630 1620 -630 { lab=#net4}
N 1620 -630 1620 -570 { lab=#net4}
N 1550 -570 1620 -570 { lab=#net4}
N 1750 -570 1770 -570 { lab=#net5}
N 1750 -630 1750 -570 { lab=#net5}
N 1750 -630 2020 -630 { lab=#net5}
N 2020 -630 2020 -570 { lab=#net5}
N 1950 -570 2020 -570 { lab=#net5}
N 780 -590 950 -590 { lab=#net2}
N 1200 -590 1370 -590 { lab=#net3}
N 1620 -590 1770 -590 { lab=#net4}
N 2340 -570 2400 -570 { lab=#net6}
N 2400 -630 2400 -570 { lab=#net6}
N 2100 -630 2400 -630 { lab=#net6}
N 2100 -630 2100 -570 { lab=#net6}
N 2100 -570 2160 -570 { lab=#net6}
N 2400 -590 2510 -590 { lab=#net6}
N 2490 -570 2510 -570 { lab=#net7}
N 2490 -630 2490 -570 { lab=#net7}
N 2490 -630 2760 -630 { lab=#net7}
N 2760 -630 2760 -570 { lab=#net7}
N 2690 -570 2760 -570 { lab=#net7}
N 2910 -570 2930 -570 { lab=#net8}
N 2910 -630 2910 -570 { lab=#net8}
N 2910 -630 3180 -630 { lab=#net8}
N 3180 -630 3180 -570 { lab=#net8}
N 3110 -570 3180 -570 { lab=#net8}
N 3330 -570 3350 -570 { lab=#net9}
N 3330 -630 3330 -570 { lab=#net9}
N 3330 -630 3600 -630 { lab=#net9}
N 3600 -630 3600 -570 { lab=#net9}
N 3530 -570 3600 -570 { lab=#net9}
N 3730 -570 3750 -570 { lab=#net10}
N 3730 -630 3730 -570 { lab=#net10}
N 3730 -630 4000 -630 { lab=#net10}
N 4000 -630 4000 -570 { lab=#net10}
N 3930 -570 4000 -570 { lab=#net10}
N 2760 -590 2930 -590 { lab=#net7}
N 3180 -590 3350 -590 { lab=#net8}
N 3600 -590 3750 -590 { lab=#net9}
N 2020 -590 2160 -590 { lab=#net5}
N 4360 -570 4420 -570 { lab=#net11}
N 4420 -630 4420 -570 { lab=#net11}
N 4120 -630 4420 -630 { lab=#net11}
N 4120 -630 4120 -570 { lab=#net11}
N 4120 -570 4180 -570 { lab=#net11}
N 4420 -590 4530 -590 { lab=#net11}
N 4510 -570 4530 -570 { lab=#net12}
N 4510 -630 4510 -570 { lab=#net12}
N 4510 -630 4780 -630 { lab=#net12}
N 4780 -630 4780 -570 { lab=#net12}
N 4710 -570 4780 -570 { lab=#net12}
N 4930 -570 4950 -570 { lab=#net13}
N 4930 -630 4930 -570 { lab=#net13}
N 4930 -630 5200 -630 { lab=#net13}
N 5200 -630 5200 -570 { lab=#net13}
N 5130 -570 5200 -570 { lab=#net13}
N 5350 -570 5370 -570 { lab=#net14}
N 5350 -630 5350 -570 { lab=#net14}
N 5350 -630 5620 -630 { lab=#net14}
N 5620 -630 5620 -570 { lab=#net14}
N 5550 -570 5620 -570 { lab=#net14}
N 5750 -570 5770 -570 { lab=#net15}
N 5750 -630 5750 -570 { lab=#net15}
N 5750 -630 6020 -630 { lab=#net15}
N 6020 -630 6020 -570 { lab=#net15}
N 5950 -570 6020 -570 { lab=#net15}
N 4780 -590 4950 -590 { lab=#net12}
N 5200 -590 5370 -590 { lab=#net13}
N 5620 -590 5770 -590 { lab=#net14}
N 6340 -570 6400 -570 { lab=#net16}
N 6400 -630 6400 -570 { lab=#net16}
N 6100 -630 6400 -630 { lab=#net16}
N 6100 -630 6100 -570 { lab=#net16}
N 6100 -570 6160 -570 { lab=#net16}
N 6400 -590 6510 -590 { lab=#net16}
N 6490 -570 6510 -570 { lab=#net17}
N 6490 -630 6490 -570 { lab=#net17}
N 6490 -630 6760 -630 { lab=#net17}
N 6760 -630 6760 -570 { lab=#net17}
N 6690 -570 6760 -570 { lab=#net17}
N 6910 -570 6930 -570 { lab=#net18}
N 6910 -630 6910 -570 { lab=#net18}
N 6910 -630 7180 -630 { lab=#net18}
N 7180 -630 7180 -570 { lab=#net18}
N 7110 -570 7180 -570 { lab=#net18}
N 7330 -570 7350 -570 { lab=#net19}
N 7330 -630 7330 -570 { lab=#net19}
N 7330 -630 7600 -630 { lab=#net19}
N 7600 -630 7600 -570 { lab=#net19}
N 7530 -570 7600 -570 { lab=#net19}
N 7730 -570 7750 -570 { lab=#net20}
N 7730 -630 7730 -570 { lab=#net20}
N 7730 -630 8000 -630 { lab=#net20}
N 8000 -630 8000 -570 { lab=#net20}
N 7930 -570 8000 -570 { lab=#net20}
N 6760 -590 6930 -590 { lab=#net17}
N 7180 -590 7350 -590 { lab=#net18}
N 7600 -590 7750 -590 { lab=#net19}
N 6020 -590 6160 -590 { lab=#net15}
N 4000 -590 4180 -590 { lab=#net10}
N 360 -680 360 -590 { lab=out0}
N 710 -680 710 -590 { lab=out1}
N 1130 -680 1130 -590 { lab=out2}
N 1550 -680 1550 -590 { lab=out3}
N 1950 -680 1950 -590 { lab=out4}
N 2340 -670 2340 -590 { lab=out5}
N 2690 -670 2690 -590 { lab=out6}
N 3110 -670 3110 -590 { lab=out7}
N 3530 -670 3530 -590 { lab=out8}
N 3930 -670 3930 -590 { lab=out9}
N 4360 -670 4360 -590 { lab=out10}
N 4710 -660 4710 -590 { lab=out11}
N 5130 -650 5130 -590 { lab=out12}
N 5550 -650 5550 -590 { lab=out13}
N 5950 -650 5950 -590 { lab=out14}
N 6340 -650 6340 -590 { lab=out15}
N 6690 -650 6690 -590 { lab=out16}
N 7110 -650 7110 -590 { lab=out17}
N 7530 -650 7530 -590 { lab=out18}
N 7930 -650 7930 -590 { lab=out19}
N 7740 -550 7750 -550 { lab=RESET}
N 80 -550 180 -550 { lab=RESET}
N 60 -590 180 -590 { lab=RESET}
C {lab_pin.sym} 180 -550 0 0 {name=l64 sig_type=std_logic lab=RESET}
C {lab_pin.sym} 180 -590 0 0 {name=l66 sig_type=std_logic lab=vout}
C {lab_pin.sym} 360 -590 2 0 {name=l135 sig_type=std_logic lab=out0}
C {lab_pin.sym} 530 -550 0 0 {name=l164 sig_type=std_logic lab=RESET}
C {lab_pin.sym} 710 -590 2 0 {name=l258 sig_type=std_logic lab=out1}
C {lab_pin.sym} 950 -550 0 0 {name=l276 sig_type=std_logic lab=RESET}
C {lab_pin.sym} 1130 -590 2 0 {name=l277 sig_type=std_logic lab=out2}
C {lab_pin.sym} 1370 -550 0 0 {name=l278 sig_type=std_logic lab=RESET}
C {lab_pin.sym} 1550 -590 2 0 {name=l279 sig_type=std_logic lab=out3}
C {lab_pin.sym} 1770 -550 0 0 {name=l280 sig_type=std_logic lab=RESET}
C {lab_pin.sym} 1950 -590 2 0 {name=l281 sig_type=std_logic lab=out4}
C {lab_pin.sym} 2160 -550 0 0 {name=l282 sig_type=std_logic lab=RESET}
C {lab_pin.sym} 2340 -590 2 0 {name=l283 sig_type=std_logic lab=out5}
C {lab_pin.sym} 2510 -550 0 0 {name=l284 sig_type=std_logic lab=RESET}
C {lab_pin.sym} 2690 -590 2 0 {name=l285 sig_type=std_logic lab=out6}
C {lab_pin.sym} 2930 -550 0 0 {name=l286 sig_type=std_logic lab=RESET}
C {lab_pin.sym} 3110 -590 2 0 {name=l287 sig_type=std_logic lab=out7}
C {lab_pin.sym} 3350 -550 0 0 {name=l288 sig_type=std_logic lab=RESET}
C {lab_pin.sym} 3530 -590 2 0 {name=l289 sig_type=std_logic lab=out8}
C {lab_pin.sym} 3750 -550 0 0 {name=l290 sig_type=std_logic lab=RESET}
C {lab_pin.sym} 3930 -590 2 0 {name=l291 sig_type=std_logic lab=out9}
C {lab_pin.sym} 4180 -550 0 0 {name=l292 sig_type=std_logic lab=RESET}
C {lab_pin.sym} 4360 -590 2 0 {name=l293 sig_type=std_logic lab=out10}
C {lab_pin.sym} 4530 -550 0 0 {name=l294 sig_type=std_logic lab=RESET}
C {lab_pin.sym} 4710 -590 2 0 {name=l295 sig_type=std_logic lab=out11}
C {lab_pin.sym} 4950 -550 0 0 {name=l296 sig_type=std_logic lab=RESET}
C {lab_pin.sym} 5130 -590 2 0 {name=l297 sig_type=std_logic lab=out12}
C {lab_pin.sym} 5370 -550 0 0 {name=l298 sig_type=std_logic lab=RESET}
C {lab_pin.sym} 5550 -590 2 0 {name=l299 sig_type=std_logic lab=out13}
C {lab_pin.sym} 5770 -550 0 0 {name=l300 sig_type=std_logic lab=RESET}
C {lab_pin.sym} 5950 -590 2 0 {name=l301 sig_type=std_logic lab=out14}
C {lab_pin.sym} 6160 -550 0 0 {name=l302 sig_type=std_logic lab=RESET}
C {lab_pin.sym} 6340 -590 2 0 {name=l303 sig_type=std_logic lab=out15}
C {lab_pin.sym} 6510 -550 0 0 {name=l304 sig_type=std_logic lab=RESET}
C {lab_pin.sym} 6690 -590 2 0 {name=l305 sig_type=std_logic lab=out16}
C {lab_pin.sym} 6930 -550 0 0 {name=l306 sig_type=std_logic lab=RESET}
C {lab_pin.sym} 7110 -590 2 0 {name=l307 sig_type=std_logic lab=out17}
C {lab_pin.sym} 7350 -550 0 0 {name=l308 sig_type=std_logic lab=RESET}
C {lab_pin.sym} 7530 -590 2 0 {name=l309 sig_type=std_logic lab=out18}
C {lab_pin.sym} 7750 -550 0 0 {name=l310 sig_type=std_logic lab=RESET}
C {lab_pin.sym} 7930 -590 2 0 {name=l311 sig_type=std_logic lab=out19}
C {/home/dhurga/dfrbp_1.sym} 270 -570 0 0 {name=x21 VGND=GND VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {/home/dhurga/dfrbp_1.sym} 620 -570 0 0 {name=x1 VGND=GND VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {/home/dhurga/dfrbp_1.sym} 1040 -570 0 0 {name=x2 VGND=GND VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {/home/dhurga/dfrbp_1.sym} 1460 -570 0 0 {name=x3 VGND=GND VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {/home/dhurga/dfrbp_1.sym} 1860 -570 0 0 {name=x4 VGND=GND VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {/home/dhurga/dfrbp_1.sym} 2250 -570 0 0 {name=x5 VGND=GND VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {/home/dhurga/dfrbp_1.sym} 2600 -570 0 0 {name=x6 VGND=GND VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {/home/dhurga/dfrbp_1.sym} 3020 -570 0 0 {name=x7 VGND=GND VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {/home/dhurga/dfrbp_1.sym} 3440 -570 0 0 {name=x8 VGND=GND VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {/home/dhurga/dfrbp_1.sym} 3840 -570 0 0 {name=x9 VGND=GND VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {/home/dhurga/dfrbp_1.sym} 4270 -570 0 0 {name=x10 VGND=GND VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {/home/dhurga/dfrbp_1.sym} 4620 -570 0 0 {name=x11 VGND=GND VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {/home/dhurga/dfrbp_1.sym} 5040 -570 0 0 {name=x12 VGND=GND VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {/home/dhurga/dfrbp_1.sym} 5460 -570 0 0 {name=x13 VGND=GND VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {/home/dhurga/dfrbp_1.sym} 5860 -570 0 0 {name=x14 VGND=GND VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {/home/dhurga/dfrbp_1.sym} 6250 -570 0 0 {name=x15 VGND=GND VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {/home/dhurga/dfrbp_1.sym} 6600 -570 0 0 {name=x16 VGND=GND VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {/home/dhurga/dfrbp_1.sym} 7020 -570 0 0 {name=x17 VGND=GND VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {/home/dhurga/dfrbp_1.sym} 7440 -570 0 0 {name=x18 VGND=GND VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {/home/dhurga/dfrbp_1.sym} 7840 -570 0 0 {name=x19 VGND=GND VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {ipin.sym} 90 -550 0 0 {name=p1 lab=RESET}
C {opin.sym} 360 -680 0 0 {name=p2 lab=out0}
C {opin.sym} 710 -680 0 0 {name=p3 lab=out1}
C {opin.sym} 1130 -680 0 0 {name=p4 lab=out2}
C {opin.sym} 1550 -680 0 0 {name=p5 lab=out3}
C {opin.sym} 1950 -680 0 0 {name=p6 lab=out4}
C {opin.sym} 2340 -670 0 0 {name=p7 lab=out5}
C {opin.sym} 2690 -670 0 0 {name=p8 lab=out6}
C {opin.sym} 3110 -670 0 0 {name=p9 lab=out7}
C {opin.sym} 3530 -670 0 0 {name=p10 lab=out8}
C {opin.sym} 3930 -670 0 0 {name=p11 lab=out9}
C {opin.sym} 4360 -670 0 0 {name=p12 lab=out10}
C {opin.sym} 4710 -660 0 0 {name=p13 lab=out11}
C {opin.sym} 5130 -650 0 0 {name=p14 lab=out12}
C {opin.sym} 5550 -650 0 0 {name=p15 lab=out13}
C {opin.sym} 5950 -650 0 0 {name=p16 lab=out14}
C {opin.sym} 6340 -650 0 0 {name=p17 lab=out15}
C {opin.sym} 6690 -650 0 0 {name=p18 lab=out16}
C {opin.sym} 7110 -650 0 0 {name=p19 lab=out17}
C {opin.sym} 7530 -650 0 0 {name=p20 lab=out18}
C {opin.sym} 7930 -650 0 0 {name=p21 lab=out19}
C {ipin.sym} 70 -590 0 0 {name=p22 lab=vout}
